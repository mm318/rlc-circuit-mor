* small example

RA 1 5 1
RB 1 2 2
RC 3 4 3
RD 0 4 4
RE 2 5 5

CA 1 5 1
CB 1 2 2
CC 3 4 3
CD 0 4 4
CE 2 5 5

IsA 1 4 1
IsB 2 4 2

VsC 2 3 3
VsD 5 0 4
