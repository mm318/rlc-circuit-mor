* clock tree

v_clk_src pt1 0 1

r_lev1_src1_dst2_seg1 pt1 dst2_seg1_res 1.250000e-01
l_lev1_src1_dst2_seg1 dst2_seg1_res dst2_seg2 2.500000e-11
c_lev1_src1_dst2_seg1 dst2_seg2 0 1.000000e-14

r_lev1_src1_dst2_seg2 dst2_seg2 dst2_seg2_res 1.250000e-01
l_lev1_src1_dst2_seg2 dst2_seg2_res dst2_seg3 2.500000e-11
c_lev1_src1_dst2_seg2 dst2_seg3 0 1.000000e-14

r_lev1_src1_dst2_seg3 dst2_seg3 dst2_seg3_res 1.250000e-01
l_lev1_src1_dst2_seg3 dst2_seg3_res dst2_seg4 2.500000e-11
c_lev1_src1_dst2_seg3 dst2_seg4 0 1.000000e-14

r_lev1_src1_dst2_seg4 dst2_seg4 dst2_seg4_res 1.250000e-01
l_lev1_src1_dst2_seg4 dst2_seg4_res dst2_seg5 2.500000e-11
c_lev1_src1_dst2_seg4 dst2_seg5 0 1.000000e-14

r_lev1_src1_dst2_seg5 dst2_seg5 dst2_seg5_res 1.250000e-01
l_lev1_src1_dst2_seg5 dst2_seg5_res dst2_seg6 2.500000e-11
c_lev1_src1_dst2_seg5 dst2_seg6 0 1.000000e-14

r_lev1_src1_dst2_seg6 dst2_seg6 dst2_seg6_res 1.250000e-01
l_lev1_src1_dst2_seg6 dst2_seg6_res dst2_seg7 2.500000e-11
c_lev1_src1_dst2_seg6 dst2_seg7 0 1.000000e-14

r_lev1_src1_dst2_seg7 dst2_seg7 dst2_seg7_res 1.250000e-01
l_lev1_src1_dst2_seg7 dst2_seg7_res dst2_seg8 2.500000e-11
c_lev1_src1_dst2_seg7 dst2_seg8 0 1.000000e-14

r_lev1_src1_dst2_seg8 dst2_seg8 dst2_seg8_res 1.250000e-01
l_lev1_src1_dst2_seg8 dst2_seg8_res dst2_seg9 2.500000e-11
c_lev1_src1_dst2_seg8 dst2_seg9 0 1.000000e-14

r_lev1_src1_dst2_seg9 dst2_seg9 dst2_seg9_res 1.250000e-01
l_lev1_src1_dst2_seg9 dst2_seg9_res dst2_seg10 2.500000e-11
c_lev1_src1_dst2_seg9 dst2_seg10 0 1.000000e-14

r_lev1_src1_dst2_seg10 dst2_seg10 dst2_seg10_res 1.250000e-01
l_lev1_src1_dst2_seg10 dst2_seg10_res dst2_seg11 2.500000e-11
c_lev1_src1_dst2_seg10 dst2_seg11 0 1.000000e-14

r_lev1_src1_dst2_seg11 dst2_seg11 dst2_seg11_res 1.250000e-01
l_lev1_src1_dst2_seg11 dst2_seg11_res dst2_seg12 2.500000e-11
c_lev1_src1_dst2_seg11 dst2_seg12 0 1.000000e-14

r_lev1_src1_dst2_seg12 dst2_seg12 dst2_seg12_res 1.250000e-01
l_lev1_src1_dst2_seg12 dst2_seg12_res dst2_seg13 2.500000e-11
c_lev1_src1_dst2_seg12 dst2_seg13 0 1.000000e-14

r_lev1_src1_dst2_seg13 dst2_seg13 dst2_seg13_res 1.250000e-01
l_lev1_src1_dst2_seg13 dst2_seg13_res dst2_seg14 2.500000e-11
c_lev1_src1_dst2_seg13 dst2_seg14 0 1.000000e-14

r_lev1_src1_dst2_seg14 dst2_seg14 dst2_seg14_res 1.250000e-01
l_lev1_src1_dst2_seg14 dst2_seg14_res dst2_seg15 2.500000e-11
c_lev1_src1_dst2_seg14 dst2_seg15 0 1.000000e-14

r_lev1_src1_dst2_seg15 dst2_seg15 dst2_seg15_res 1.250000e-01
l_lev1_src1_dst2_seg15 dst2_seg15_res dst2_seg16 2.500000e-11
c_lev1_src1_dst2_seg15 dst2_seg16 0 1.000000e-14

r_lev1_src1_dst2_seg16 dst2_seg16 dst2_seg16_res 1.250000e-01
l_lev1_src1_dst2_seg16 dst2_seg16_res dst2_seg17 2.500000e-11
c_lev1_src1_dst2_seg16 dst2_seg17 0 1.000000e-14

r_lev1_src1_dst2_seg17 dst2_seg17 dst2_seg17_res 1.250000e-01
l_lev1_src1_dst2_seg17 dst2_seg17_res dst2_seg18 2.500000e-11
c_lev1_src1_dst2_seg17 dst2_seg18 0 1.000000e-14

r_lev1_src1_dst2_seg18 dst2_seg18 dst2_seg18_res 1.250000e-01
l_lev1_src1_dst2_seg18 dst2_seg18_res dst2_seg19 2.500000e-11
c_lev1_src1_dst2_seg18 dst2_seg19 0 1.000000e-14

r_lev1_src1_dst2_seg19 dst2_seg19 dst2_seg19_res 1.250000e-01
l_lev1_src1_dst2_seg19 dst2_seg19_res dst2_seg20 2.500000e-11
c_lev1_src1_dst2_seg19 dst2_seg20 0 1.000000e-14

r_lev1_src1_dst2_seg20 dst2_seg20 dst2_seg20_res 1.250000e-01
l_lev1_src1_dst2_seg20 dst2_seg20_res dst2_seg21 2.500000e-11
c_lev1_src1_dst2_seg20 dst2_seg21 0 1.000000e-14

r_lev1_src1_dst2_seg21 dst2_seg21 dst2_seg21_res 1.250000e-01
l_lev1_src1_dst2_seg21 dst2_seg21_res dst2_seg22 2.500000e-11
c_lev1_src1_dst2_seg21 dst2_seg22 0 1.000000e-14

r_lev1_src1_dst2_seg22 dst2_seg22 dst2_seg22_res 1.250000e-01
l_lev1_src1_dst2_seg22 dst2_seg22_res dst2_seg23 2.500000e-11
c_lev1_src1_dst2_seg22 dst2_seg23 0 1.000000e-14

r_lev1_src1_dst2_seg23 dst2_seg23 dst2_seg23_res 1.250000e-01
l_lev1_src1_dst2_seg23 dst2_seg23_res dst2_seg24 2.500000e-11
c_lev1_src1_dst2_seg23 dst2_seg24 0 1.000000e-14

r_lev1_src1_dst2_seg24 dst2_seg24 dst2_seg24_res 1.250000e-01
l_lev1_src1_dst2_seg24 dst2_seg24_res dst2_seg25 2.500000e-11
c_lev1_src1_dst2_seg24 dst2_seg25 0 1.000000e-14

r_lev1_src1_dst2_seg25 dst2_seg25 dst2_seg25_res 1.250000e-01
l_lev1_src1_dst2_seg25 dst2_seg25_res dst2_seg26 2.500000e-11
c_lev1_src1_dst2_seg25 dst2_seg26 0 1.000000e-14

r_lev1_src1_dst2_seg26 dst2_seg26 dst2_seg26_res 1.250000e-01
l_lev1_src1_dst2_seg26 dst2_seg26_res dst2_seg27 2.500000e-11
c_lev1_src1_dst2_seg26 dst2_seg27 0 1.000000e-14

r_lev1_src1_dst2_seg27 dst2_seg27 dst2_seg27_res 1.250000e-01
l_lev1_src1_dst2_seg27 dst2_seg27_res dst2_seg28 2.500000e-11
c_lev1_src1_dst2_seg27 dst2_seg28 0 1.000000e-14

r_lev1_src1_dst2_seg28 dst2_seg28 dst2_seg28_res 1.250000e-01
l_lev1_src1_dst2_seg28 dst2_seg28_res dst2_seg29 2.500000e-11
c_lev1_src1_dst2_seg28 dst2_seg29 0 1.000000e-14

r_lev1_src1_dst2_seg29 dst2_seg29 dst2_seg29_res 1.250000e-01
l_lev1_src1_dst2_seg29 dst2_seg29_res dst2_seg30 2.500000e-11
c_lev1_src1_dst2_seg29 dst2_seg30 0 1.000000e-14

r_lev1_src1_dst2_seg30 dst2_seg30 dst2_seg30_res 1.250000e-01
l_lev1_src1_dst2_seg30 dst2_seg30_res dst2_seg31 2.500000e-11
c_lev1_src1_dst2_seg30 dst2_seg31 0 1.000000e-14

r_lev1_src1_dst2_seg31 dst2_seg31 dst2_seg31_res 1.250000e-01
l_lev1_src1_dst2_seg31 dst2_seg31_res dst2_seg32 2.500000e-11
c_lev1_src1_dst2_seg31 dst2_seg32 0 1.000000e-14

r_lev1_src1_dst2_seg32 dst2_seg32 dst2_seg32_res 1.250000e-01
l_lev1_src1_dst2_seg32 dst2_seg32_res dst2_seg33 2.500000e-11
c_lev1_src1_dst2_seg32 dst2_seg33 0 1.000000e-14

r_lev1_src1_dst2_seg33 dst2_seg33 dst2_seg33_res 1.250000e-01
l_lev1_src1_dst2_seg33 dst2_seg33_res dst2_seg34 2.500000e-11
c_lev1_src1_dst2_seg33 dst2_seg34 0 1.000000e-14

r_lev1_src1_dst2_seg34 dst2_seg34 dst2_seg34_res 1.250000e-01
l_lev1_src1_dst2_seg34 dst2_seg34_res dst2_seg35 2.500000e-11
c_lev1_src1_dst2_seg34 dst2_seg35 0 1.000000e-14

r_lev1_src1_dst2_seg35 dst2_seg35 dst2_seg35_res 1.250000e-01
l_lev1_src1_dst2_seg35 dst2_seg35_res dst2_seg36 2.500000e-11
c_lev1_src1_dst2_seg35 dst2_seg36 0 1.000000e-14

r_lev1_src1_dst2_seg36 dst2_seg36 dst2_seg36_res 1.250000e-01
l_lev1_src1_dst2_seg36 dst2_seg36_res dst2_seg37 2.500000e-11
c_lev1_src1_dst2_seg36 dst2_seg37 0 1.000000e-14

r_lev1_src1_dst2_seg37 dst2_seg37 dst2_seg37_res 1.250000e-01
l_lev1_src1_dst2_seg37 dst2_seg37_res dst2_seg38 2.500000e-11
c_lev1_src1_dst2_seg37 dst2_seg38 0 1.000000e-14

r_lev1_src1_dst2_seg38 dst2_seg38 dst2_seg38_res 1.250000e-01
l_lev1_src1_dst2_seg38 dst2_seg38_res dst2_seg39 2.500000e-11
c_lev1_src1_dst2_seg38 dst2_seg39 0 1.000000e-14

r_lev1_src1_dst2_seg39 dst2_seg39 dst2_seg39_res 1.250000e-01
l_lev1_src1_dst2_seg39 dst2_seg39_res dst2_seg40 2.500000e-11
c_lev1_src1_dst2_seg39 dst2_seg40 0 1.000000e-14

r_lev1_src1_dst2_seg40 dst2_seg40 dst2_seg40_res 1.250000e-01
l_lev1_src1_dst2_seg40 dst2_seg40_res dst2_seg41 2.500000e-11
c_lev1_src1_dst2_seg40 dst2_seg41 0 1.000000e-14

r_lev1_src1_dst2_seg41 dst2_seg41 dst2_seg41_res 1.250000e-01
l_lev1_src1_dst2_seg41 dst2_seg41_res dst2_seg42 2.500000e-11
c_lev1_src1_dst2_seg41 dst2_seg42 0 1.000000e-14

r_lev1_src1_dst2_seg42 dst2_seg42 dst2_seg42_res 1.250000e-01
l_lev1_src1_dst2_seg42 dst2_seg42_res dst2_seg43 2.500000e-11
c_lev1_src1_dst2_seg42 dst2_seg43 0 1.000000e-14

r_lev1_src1_dst2_seg43 dst2_seg43 dst2_seg43_res 1.250000e-01
l_lev1_src1_dst2_seg43 dst2_seg43_res dst2_seg44 2.500000e-11
c_lev1_src1_dst2_seg43 dst2_seg44 0 1.000000e-14

r_lev1_src1_dst2_seg44 dst2_seg44 dst2_seg44_res 1.250000e-01
l_lev1_src1_dst2_seg44 dst2_seg44_res dst2_seg45 2.500000e-11
c_lev1_src1_dst2_seg44 dst2_seg45 0 1.000000e-14

r_lev1_src1_dst2_seg45 dst2_seg45 dst2_seg45_res 1.250000e-01
l_lev1_src1_dst2_seg45 dst2_seg45_res dst2_seg46 2.500000e-11
c_lev1_src1_dst2_seg45 dst2_seg46 0 1.000000e-14

r_lev1_src1_dst2_seg46 dst2_seg46 dst2_seg46_res 1.250000e-01
l_lev1_src1_dst2_seg46 dst2_seg46_res dst2_seg47 2.500000e-11
c_lev1_src1_dst2_seg46 dst2_seg47 0 1.000000e-14

r_lev1_src1_dst2_seg47 dst2_seg47 dst2_seg47_res 1.250000e-01
l_lev1_src1_dst2_seg47 dst2_seg47_res dst2_seg48 2.500000e-11
c_lev1_src1_dst2_seg47 dst2_seg48 0 1.000000e-14

r_lev1_src1_dst2_seg48 dst2_seg48 dst2_seg48_res 1.250000e-01
l_lev1_src1_dst2_seg48 dst2_seg48_res dst2_seg49 2.500000e-11
c_lev1_src1_dst2_seg48 dst2_seg49 0 1.000000e-14

r_lev1_src1_dst2_seg49 dst2_seg49 dst2_seg49_res 1.250000e-01
l_lev1_src1_dst2_seg49 dst2_seg49_res dst2_seg50 2.500000e-11
c_lev1_src1_dst2_seg49 dst2_seg50 0 1.000000e-14

r_lev1_src1_dst2_seg50 dst2_seg50 dst2_seg50_res 1.250000e-01
l_lev1_src1_dst2_seg50 dst2_seg50_res dst2_seg51 2.500000e-11
c_lev1_src1_dst2_seg50 dst2_seg51 0 1.000000e-14

r_lev1_src1_dst2_seg51 dst2_seg51 dst2_seg51_res 1.250000e-01
l_lev1_src1_dst2_seg51 dst2_seg51_res dst2_seg52 2.500000e-11
c_lev1_src1_dst2_seg51 dst2_seg52 0 1.000000e-14

r_lev1_src1_dst2_seg52 dst2_seg52 dst2_seg52_res 1.250000e-01
l_lev1_src1_dst2_seg52 dst2_seg52_res dst2_seg53 2.500000e-11
c_lev1_src1_dst2_seg52 dst2_seg53 0 1.000000e-14

r_lev1_src1_dst2_seg53 dst2_seg53 dst2_seg53_res 1.250000e-01
l_lev1_src1_dst2_seg53 dst2_seg53_res dst2_seg54 2.500000e-11
c_lev1_src1_dst2_seg53 dst2_seg54 0 1.000000e-14

r_lev1_src1_dst2_seg54 dst2_seg54 dst2_seg54_res 1.250000e-01
l_lev1_src1_dst2_seg54 dst2_seg54_res dst2_seg55 2.500000e-11
c_lev1_src1_dst2_seg54 dst2_seg55 0 1.000000e-14

r_lev1_src1_dst2_seg55 dst2_seg55 dst2_seg55_res 1.250000e-01
l_lev1_src1_dst2_seg55 dst2_seg55_res dst2_seg56 2.500000e-11
c_lev1_src1_dst2_seg55 dst2_seg56 0 1.000000e-14

r_lev1_src1_dst2_seg56 dst2_seg56 dst2_seg56_res 1.250000e-01
l_lev1_src1_dst2_seg56 dst2_seg56_res dst2_seg57 2.500000e-11
c_lev1_src1_dst2_seg56 dst2_seg57 0 1.000000e-14

r_lev1_src1_dst2_seg57 dst2_seg57 dst2_seg57_res 1.250000e-01
l_lev1_src1_dst2_seg57 dst2_seg57_res dst2_seg58 2.500000e-11
c_lev1_src1_dst2_seg57 dst2_seg58 0 1.000000e-14

r_lev1_src1_dst2_seg58 dst2_seg58 dst2_seg58_res 1.250000e-01
l_lev1_src1_dst2_seg58 dst2_seg58_res dst2_seg59 2.500000e-11
c_lev1_src1_dst2_seg58 dst2_seg59 0 1.000000e-14

r_lev1_src1_dst2_seg59 dst2_seg59 dst2_seg59_res 1.250000e-01
l_lev1_src1_dst2_seg59 dst2_seg59_res dst2_seg60 2.500000e-11
c_lev1_src1_dst2_seg59 dst2_seg60 0 1.000000e-14

r_lev1_src1_dst2_seg60 dst2_seg60 dst2_seg60_res 1.250000e-01
l_lev1_src1_dst2_seg60 dst2_seg60_res dst2_seg61 2.500000e-11
c_lev1_src1_dst2_seg60 dst2_seg61 0 1.000000e-14

r_lev1_src1_dst2_seg61 dst2_seg61 dst2_seg61_res 1.250000e-01
l_lev1_src1_dst2_seg61 dst2_seg61_res dst2_seg62 2.500000e-11
c_lev1_src1_dst2_seg61 dst2_seg62 0 1.000000e-14

r_lev1_src1_dst2_seg62 dst2_seg62 dst2_seg62_res 1.250000e-01
l_lev1_src1_dst2_seg62 dst2_seg62_res dst2_seg63 2.500000e-11
c_lev1_src1_dst2_seg62 dst2_seg63 0 1.000000e-14

r_lev1_src1_dst2_seg63 dst2_seg63 dst2_seg63_res 1.250000e-01
l_lev1_src1_dst2_seg63 dst2_seg63_res dst2_seg64 2.500000e-11
c_lev1_src1_dst2_seg63 dst2_seg64 0 1.000000e-14

r_lev1_src1_dst2_seg64 dst2_seg64 dst2_seg64_res 1.250000e-01
l_lev1_src1_dst2_seg64 dst2_seg64_res dst2_seg65 2.500000e-11
c_lev1_src1_dst2_seg64 dst2_seg65 0 1.000000e-14

r_lev1_src1_dst2_seg65 dst2_seg65 dst2_seg65_res 1.250000e-01
l_lev1_src1_dst2_seg65 dst2_seg65_res dst2_seg66 2.500000e-11
c_lev1_src1_dst2_seg65 dst2_seg66 0 1.000000e-14

r_lev1_src1_dst2_seg66 dst2_seg66 dst2_seg66_res 1.250000e-01
l_lev1_src1_dst2_seg66 dst2_seg66_res dst2_seg67 2.500000e-11
c_lev1_src1_dst2_seg66 dst2_seg67 0 1.000000e-14

r_lev1_src1_dst2_seg67 dst2_seg67 dst2_seg67_res 1.250000e-01
l_lev1_src1_dst2_seg67 dst2_seg67_res dst2_seg68 2.500000e-11
c_lev1_src1_dst2_seg67 dst2_seg68 0 1.000000e-14

r_lev1_src1_dst2_seg68 dst2_seg68 dst2_seg68_res 1.250000e-01
l_lev1_src1_dst2_seg68 dst2_seg68_res dst2_seg69 2.500000e-11
c_lev1_src1_dst2_seg68 dst2_seg69 0 1.000000e-14

r_lev1_src1_dst2_seg69 dst2_seg69 dst2_seg69_res 1.250000e-01
l_lev1_src1_dst2_seg69 dst2_seg69_res dst2_seg70 2.500000e-11
c_lev1_src1_dst2_seg69 dst2_seg70 0 1.000000e-14

r_lev1_src1_dst2_seg70 dst2_seg70 dst2_seg70_res 1.250000e-01
l_lev1_src1_dst2_seg70 dst2_seg70_res dst2_seg71 2.500000e-11
c_lev1_src1_dst2_seg70 dst2_seg71 0 1.000000e-14

r_lev1_src1_dst2_seg71 dst2_seg71 dst2_seg71_res 1.250000e-01
l_lev1_src1_dst2_seg71 dst2_seg71_res dst2_seg72 2.500000e-11
c_lev1_src1_dst2_seg71 dst2_seg72 0 1.000000e-14

r_lev1_src1_dst2_seg72 dst2_seg72 dst2_seg72_res 1.250000e-01
l_lev1_src1_dst2_seg72 dst2_seg72_res dst2_seg73 2.500000e-11
c_lev1_src1_dst2_seg72 dst2_seg73 0 1.000000e-14

r_lev1_src1_dst2_seg73 dst2_seg73 dst2_seg73_res 1.250000e-01
l_lev1_src1_dst2_seg73 dst2_seg73_res dst2_seg74 2.500000e-11
c_lev1_src1_dst2_seg73 dst2_seg74 0 1.000000e-14

r_lev1_src1_dst2_seg74 dst2_seg74 dst2_seg74_res 1.250000e-01
l_lev1_src1_dst2_seg74 dst2_seg74_res dst2_seg75 2.500000e-11
c_lev1_src1_dst2_seg74 dst2_seg75 0 1.000000e-14

r_lev1_src1_dst2_seg75 dst2_seg75 dst2_seg75_res 1.250000e-01
l_lev1_src1_dst2_seg75 dst2_seg75_res dst2_seg76 2.500000e-11
c_lev1_src1_dst2_seg75 dst2_seg76 0 1.000000e-14

r_lev1_src1_dst2_seg76 dst2_seg76 dst2_seg76_res 1.250000e-01
l_lev1_src1_dst2_seg76 dst2_seg76_res dst2_seg77 2.500000e-11
c_lev1_src1_dst2_seg76 dst2_seg77 0 1.000000e-14

r_lev1_src1_dst2_seg77 dst2_seg77 dst2_seg77_res 1.250000e-01
l_lev1_src1_dst2_seg77 dst2_seg77_res dst2_seg78 2.500000e-11
c_lev1_src1_dst2_seg77 dst2_seg78 0 1.000000e-14

r_lev1_src1_dst2_seg78 dst2_seg78 dst2_seg78_res 1.250000e-01
l_lev1_src1_dst2_seg78 dst2_seg78_res dst2_seg79 2.500000e-11
c_lev1_src1_dst2_seg78 dst2_seg79 0 1.000000e-14

r_lev1_src1_dst2_seg79 dst2_seg79 dst2_seg79_res 1.250000e-01
l_lev1_src1_dst2_seg79 dst2_seg79_res dst2_seg80 2.500000e-11
c_lev1_src1_dst2_seg79 dst2_seg80 0 1.000000e-14

r_lev1_src1_dst2_seg80 dst2_seg80 dst2_seg80_res 1.250000e-01
l_lev1_src1_dst2_seg80 dst2_seg80_res dst2_seg81 2.500000e-11
c_lev1_src1_dst2_seg80 dst2_seg81 0 1.000000e-14

r_lev1_src1_dst2_seg81 dst2_seg81 dst2_seg81_res 1.250000e-01
l_lev1_src1_dst2_seg81 dst2_seg81_res dst2_seg82 2.500000e-11
c_lev1_src1_dst2_seg81 dst2_seg82 0 1.000000e-14

r_lev1_src1_dst2_seg82 dst2_seg82 dst2_seg82_res 1.250000e-01
l_lev1_src1_dst2_seg82 dst2_seg82_res dst2_seg83 2.500000e-11
c_lev1_src1_dst2_seg82 dst2_seg83 0 1.000000e-14

r_lev1_src1_dst2_seg83 dst2_seg83 dst2_seg83_res 1.250000e-01
l_lev1_src1_dst2_seg83 dst2_seg83_res dst2_seg84 2.500000e-11
c_lev1_src1_dst2_seg83 dst2_seg84 0 1.000000e-14

r_lev1_src1_dst2_seg84 dst2_seg84 dst2_seg84_res 1.250000e-01
l_lev1_src1_dst2_seg84 dst2_seg84_res dst2_seg85 2.500000e-11
c_lev1_src1_dst2_seg84 dst2_seg85 0 1.000000e-14

r_lev1_src1_dst2_seg85 dst2_seg85 dst2_seg85_res 1.250000e-01
l_lev1_src1_dst2_seg85 dst2_seg85_res dst2_seg86 2.500000e-11
c_lev1_src1_dst2_seg85 dst2_seg86 0 1.000000e-14

r_lev1_src1_dst2_seg86 dst2_seg86 dst2_seg86_res 1.250000e-01
l_lev1_src1_dst2_seg86 dst2_seg86_res dst2_seg87 2.500000e-11
c_lev1_src1_dst2_seg86 dst2_seg87 0 1.000000e-14

r_lev1_src1_dst2_seg87 dst2_seg87 dst2_seg87_res 1.250000e-01
l_lev1_src1_dst2_seg87 dst2_seg87_res dst2_seg88 2.500000e-11
c_lev1_src1_dst2_seg87 dst2_seg88 0 1.000000e-14

r_lev1_src1_dst2_seg88 dst2_seg88 dst2_seg88_res 1.250000e-01
l_lev1_src1_dst2_seg88 dst2_seg88_res dst2_seg89 2.500000e-11
c_lev1_src1_dst2_seg88 dst2_seg89 0 1.000000e-14

r_lev1_src1_dst2_seg89 dst2_seg89 dst2_seg89_res 1.250000e-01
l_lev1_src1_dst2_seg89 dst2_seg89_res dst2_seg90 2.500000e-11
c_lev1_src1_dst2_seg89 dst2_seg90 0 1.000000e-14

r_lev1_src1_dst2_seg90 dst2_seg90 dst2_seg90_res 1.250000e-01
l_lev1_src1_dst2_seg90 dst2_seg90_res dst2_seg91 2.500000e-11
c_lev1_src1_dst2_seg90 dst2_seg91 0 1.000000e-14

r_lev1_src1_dst2_seg91 dst2_seg91 dst2_seg91_res 1.250000e-01
l_lev1_src1_dst2_seg91 dst2_seg91_res dst2_seg92 2.500000e-11
c_lev1_src1_dst2_seg91 dst2_seg92 0 1.000000e-14

r_lev1_src1_dst2_seg92 dst2_seg92 dst2_seg92_res 1.250000e-01
l_lev1_src1_dst2_seg92 dst2_seg92_res dst2_seg93 2.500000e-11
c_lev1_src1_dst2_seg92 dst2_seg93 0 1.000000e-14

r_lev1_src1_dst2_seg93 dst2_seg93 dst2_seg93_res 1.250000e-01
l_lev1_src1_dst2_seg93 dst2_seg93_res dst2_seg94 2.500000e-11
c_lev1_src1_dst2_seg93 dst2_seg94 0 1.000000e-14

r_lev1_src1_dst2_seg94 dst2_seg94 dst2_seg94_res 1.250000e-01
l_lev1_src1_dst2_seg94 dst2_seg94_res dst2_seg95 2.500000e-11
c_lev1_src1_dst2_seg94 dst2_seg95 0 1.000000e-14

r_lev1_src1_dst2_seg95 dst2_seg95 dst2_seg95_res 1.250000e-01
l_lev1_src1_dst2_seg95 dst2_seg95_res dst2_seg96 2.500000e-11
c_lev1_src1_dst2_seg95 dst2_seg96 0 1.000000e-14

r_lev1_src1_dst2_seg96 dst2_seg96 dst2_seg96_res 1.250000e-01
l_lev1_src1_dst2_seg96 dst2_seg96_res dst2_seg97 2.500000e-11
c_lev1_src1_dst2_seg96 dst2_seg97 0 1.000000e-14

r_lev1_src1_dst2_seg97 dst2_seg97 dst2_seg97_res 1.250000e-01
l_lev1_src1_dst2_seg97 dst2_seg97_res dst2_seg98 2.500000e-11
c_lev1_src1_dst2_seg97 dst2_seg98 0 1.000000e-14

r_lev1_src1_dst2_seg98 dst2_seg98 dst2_seg98_res 1.250000e-01
l_lev1_src1_dst2_seg98 dst2_seg98_res dst2_seg99 2.500000e-11
c_lev1_src1_dst2_seg98 dst2_seg99 0 1.000000e-14

r_lev1_src1_dst2_seg99 dst2_seg99 dst2_seg99_res 1.250000e-01
l_lev1_src1_dst2_seg99 dst2_seg99_res dst2_seg100 2.500000e-11
c_lev1_src1_dst2_seg99 dst2_seg100 0 1.000000e-14

r_lev1_src1_dst2_seg100 dst2_seg100 dst2_seg100_res 1.250000e-01
l_lev1_src1_dst2_seg100 dst2_seg100_res dst2_seg101 2.500000e-11
c_lev1_src1_dst2_seg100 dst2_seg101 0 1.000000e-14

r_lev1_src1_dst2_seg101 dst2_seg101 dst2_seg101_res 1.250000e-01
l_lev1_src1_dst2_seg101 dst2_seg101_res dst2_seg102 2.500000e-11
c_lev1_src1_dst2_seg101 dst2_seg102 0 1.000000e-14

r_lev1_src1_dst2_seg102 dst2_seg102 dst2_seg102_res 1.250000e-01
l_lev1_src1_dst2_seg102 dst2_seg102_res dst2_seg103 2.500000e-11
c_lev1_src1_dst2_seg102 dst2_seg103 0 1.000000e-14

r_lev1_src1_dst2_seg103 dst2_seg103 dst2_seg103_res 1.250000e-01
l_lev1_src1_dst2_seg103 dst2_seg103_res dst2_seg104 2.500000e-11
c_lev1_src1_dst2_seg103 dst2_seg104 0 1.000000e-14

r_lev1_src1_dst2_seg104 dst2_seg104 dst2_seg104_res 1.250000e-01
l_lev1_src1_dst2_seg104 dst2_seg104_res dst2_seg105 2.500000e-11
c_lev1_src1_dst2_seg104 dst2_seg105 0 1.000000e-14

r_lev1_src1_dst2_seg105 dst2_seg105 dst2_seg105_res 1.250000e-01
l_lev1_src1_dst2_seg105 dst2_seg105_res dst2_seg106 2.500000e-11
c_lev1_src1_dst2_seg105 dst2_seg106 0 1.000000e-14

r_lev1_src1_dst2_seg106 dst2_seg106 dst2_seg106_res 1.250000e-01
l_lev1_src1_dst2_seg106 dst2_seg106_res dst2_seg107 2.500000e-11
c_lev1_src1_dst2_seg106 dst2_seg107 0 1.000000e-14

r_lev1_src1_dst2_seg107 dst2_seg107 dst2_seg107_res 1.250000e-01
l_lev1_src1_dst2_seg107 dst2_seg107_res dst2_seg108 2.500000e-11
c_lev1_src1_dst2_seg107 dst2_seg108 0 1.000000e-14

r_lev1_src1_dst2_seg108 dst2_seg108 dst2_seg108_res 1.250000e-01
l_lev1_src1_dst2_seg108 dst2_seg108_res dst2_seg109 2.500000e-11
c_lev1_src1_dst2_seg108 dst2_seg109 0 1.000000e-14

r_lev1_src1_dst2_seg109 dst2_seg109 dst2_seg109_res 1.250000e-01
l_lev1_src1_dst2_seg109 dst2_seg109_res dst2_seg110 2.500000e-11
c_lev1_src1_dst2_seg109 dst2_seg110 0 1.000000e-14

r_lev1_src1_dst2_seg110 dst2_seg110 dst2_seg110_res 1.250000e-01
l_lev1_src1_dst2_seg110 dst2_seg110_res dst2_seg111 2.500000e-11
c_lev1_src1_dst2_seg110 dst2_seg111 0 1.000000e-14

r_lev1_src1_dst2_seg111 dst2_seg111 dst2_seg111_res 1.250000e-01
l_lev1_src1_dst2_seg111 dst2_seg111_res dst2_seg112 2.500000e-11
c_lev1_src1_dst2_seg111 dst2_seg112 0 1.000000e-14

r_lev1_src1_dst2_seg112 dst2_seg112 dst2_seg112_res 1.250000e-01
l_lev1_src1_dst2_seg112 dst2_seg112_res dst2_seg113 2.500000e-11
c_lev1_src1_dst2_seg112 dst2_seg113 0 1.000000e-14

r_lev1_src1_dst2_seg113 dst2_seg113 dst2_seg113_res 1.250000e-01
l_lev1_src1_dst2_seg113 dst2_seg113_res dst2_seg114 2.500000e-11
c_lev1_src1_dst2_seg113 dst2_seg114 0 1.000000e-14

r_lev1_src1_dst2_seg114 dst2_seg114 dst2_seg114_res 1.250000e-01
l_lev1_src1_dst2_seg114 dst2_seg114_res dst2_seg115 2.500000e-11
c_lev1_src1_dst2_seg114 dst2_seg115 0 1.000000e-14

r_lev1_src1_dst2_seg115 dst2_seg115 dst2_seg115_res 1.250000e-01
l_lev1_src1_dst2_seg115 dst2_seg115_res dst2_seg116 2.500000e-11
c_lev1_src1_dst2_seg115 dst2_seg116 0 1.000000e-14

r_lev1_src1_dst2_seg116 dst2_seg116 dst2_seg116_res 1.250000e-01
l_lev1_src1_dst2_seg116 dst2_seg116_res dst2_seg117 2.500000e-11
c_lev1_src1_dst2_seg116 dst2_seg117 0 1.000000e-14

r_lev1_src1_dst2_seg117 dst2_seg117 dst2_seg117_res 1.250000e-01
l_lev1_src1_dst2_seg117 dst2_seg117_res dst2_seg118 2.500000e-11
c_lev1_src1_dst2_seg117 dst2_seg118 0 1.000000e-14

r_lev1_src1_dst2_seg118 dst2_seg118 dst2_seg118_res 1.250000e-01
l_lev1_src1_dst2_seg118 dst2_seg118_res dst2_seg119 2.500000e-11
c_lev1_src1_dst2_seg118 dst2_seg119 0 1.000000e-14

r_lev1_src1_dst2_seg119 dst2_seg119 dst2_seg119_res 1.250000e-01
l_lev1_src1_dst2_seg119 dst2_seg119_res dst2_seg120 2.500000e-11
c_lev1_src1_dst2_seg119 dst2_seg120 0 1.000000e-14

r_lev1_src1_dst2_seg120 dst2_seg120 dst2_seg120_res 1.250000e-01
l_lev1_src1_dst2_seg120 dst2_seg120_res pt2 2.500000e-11
c_lev1_src1_dst2_seg120 pt2 0 1.000000e-14

r_lev2_src2_dst3_seg1 pt2 dst3_seg1_res 1.785000e-01
l_lev2_src2_dst3_seg1 dst3_seg1_res dst3_seg2 3.570000e-11
c_lev2_src2_dst3_seg1 dst3_seg2 0 7.000000e-15

r_lev2_src2_dst3_seg2 dst3_seg2 dst3_seg2_res 1.785000e-01
l_lev2_src2_dst3_seg2 dst3_seg2_res dst3_seg3 3.570000e-11
c_lev2_src2_dst3_seg2 dst3_seg3 0 7.000000e-15

r_lev2_src2_dst3_seg3 dst3_seg3 dst3_seg3_res 1.785000e-01
l_lev2_src2_dst3_seg3 dst3_seg3_res dst3_seg4 3.570000e-11
c_lev2_src2_dst3_seg3 dst3_seg4 0 7.000000e-15

r_lev2_src2_dst3_seg4 dst3_seg4 dst3_seg4_res 1.785000e-01
l_lev2_src2_dst3_seg4 dst3_seg4_res dst3_seg5 3.570000e-11
c_lev2_src2_dst3_seg4 dst3_seg5 0 7.000000e-15

r_lev2_src2_dst3_seg5 dst3_seg5 dst3_seg5_res 1.785000e-01
l_lev2_src2_dst3_seg5 dst3_seg5_res dst3_seg6 3.570000e-11
c_lev2_src2_dst3_seg5 dst3_seg6 0 7.000000e-15

r_lev2_src2_dst3_seg6 dst3_seg6 dst3_seg6_res 1.785000e-01
l_lev2_src2_dst3_seg6 dst3_seg6_res dst3_seg7 3.570000e-11
c_lev2_src2_dst3_seg6 dst3_seg7 0 7.000000e-15

r_lev2_src2_dst3_seg7 dst3_seg7 dst3_seg7_res 1.785000e-01
l_lev2_src2_dst3_seg7 dst3_seg7_res dst3_seg8 3.570000e-11
c_lev2_src2_dst3_seg7 dst3_seg8 0 7.000000e-15

r_lev2_src2_dst3_seg8 dst3_seg8 dst3_seg8_res 1.785000e-01
l_lev2_src2_dst3_seg8 dst3_seg8_res dst3_seg9 3.570000e-11
c_lev2_src2_dst3_seg8 dst3_seg9 0 7.000000e-15

r_lev2_src2_dst3_seg9 dst3_seg9 dst3_seg9_res 1.785000e-01
l_lev2_src2_dst3_seg9 dst3_seg9_res dst3_seg10 3.570000e-11
c_lev2_src2_dst3_seg9 dst3_seg10 0 7.000000e-15

r_lev2_src2_dst3_seg10 dst3_seg10 dst3_seg10_res 1.785000e-01
l_lev2_src2_dst3_seg10 dst3_seg10_res dst3_seg11 3.570000e-11
c_lev2_src2_dst3_seg10 dst3_seg11 0 7.000000e-15

r_lev2_src2_dst3_seg11 dst3_seg11 dst3_seg11_res 1.785000e-01
l_lev2_src2_dst3_seg11 dst3_seg11_res dst3_seg12 3.570000e-11
c_lev2_src2_dst3_seg11 dst3_seg12 0 7.000000e-15

r_lev2_src2_dst3_seg12 dst3_seg12 dst3_seg12_res 1.785000e-01
l_lev2_src2_dst3_seg12 dst3_seg12_res dst3_seg13 3.570000e-11
c_lev2_src2_dst3_seg12 dst3_seg13 0 7.000000e-15

r_lev2_src2_dst3_seg13 dst3_seg13 dst3_seg13_res 1.785000e-01
l_lev2_src2_dst3_seg13 dst3_seg13_res dst3_seg14 3.570000e-11
c_lev2_src2_dst3_seg13 dst3_seg14 0 7.000000e-15

r_lev2_src2_dst3_seg14 dst3_seg14 dst3_seg14_res 1.785000e-01
l_lev2_src2_dst3_seg14 dst3_seg14_res dst3_seg15 3.570000e-11
c_lev2_src2_dst3_seg14 dst3_seg15 0 7.000000e-15

r_lev2_src2_dst3_seg15 dst3_seg15 dst3_seg15_res 1.785000e-01
l_lev2_src2_dst3_seg15 dst3_seg15_res dst3_seg16 3.570000e-11
c_lev2_src2_dst3_seg15 dst3_seg16 0 7.000000e-15

r_lev2_src2_dst3_seg16 dst3_seg16 dst3_seg16_res 1.785000e-01
l_lev2_src2_dst3_seg16 dst3_seg16_res dst3_seg17 3.570000e-11
c_lev2_src2_dst3_seg16 dst3_seg17 0 7.000000e-15

r_lev2_src2_dst3_seg17 dst3_seg17 dst3_seg17_res 1.785000e-01
l_lev2_src2_dst3_seg17 dst3_seg17_res dst3_seg18 3.570000e-11
c_lev2_src2_dst3_seg17 dst3_seg18 0 7.000000e-15

r_lev2_src2_dst3_seg18 dst3_seg18 dst3_seg18_res 1.785000e-01
l_lev2_src2_dst3_seg18 dst3_seg18_res dst3_seg19 3.570000e-11
c_lev2_src2_dst3_seg18 dst3_seg19 0 7.000000e-15

r_lev2_src2_dst3_seg19 dst3_seg19 dst3_seg19_res 1.785000e-01
l_lev2_src2_dst3_seg19 dst3_seg19_res dst3_seg20 3.570000e-11
c_lev2_src2_dst3_seg19 dst3_seg20 0 7.000000e-15

r_lev2_src2_dst3_seg20 dst3_seg20 dst3_seg20_res 1.785000e-01
l_lev2_src2_dst3_seg20 dst3_seg20_res dst3_seg21 3.570000e-11
c_lev2_src2_dst3_seg20 dst3_seg21 0 7.000000e-15

r_lev2_src2_dst3_seg21 dst3_seg21 dst3_seg21_res 1.785000e-01
l_lev2_src2_dst3_seg21 dst3_seg21_res dst3_seg22 3.570000e-11
c_lev2_src2_dst3_seg21 dst3_seg22 0 7.000000e-15

r_lev2_src2_dst3_seg22 dst3_seg22 dst3_seg22_res 1.785000e-01
l_lev2_src2_dst3_seg22 dst3_seg22_res dst3_seg23 3.570000e-11
c_lev2_src2_dst3_seg22 dst3_seg23 0 7.000000e-15

r_lev2_src2_dst3_seg23 dst3_seg23 dst3_seg23_res 1.785000e-01
l_lev2_src2_dst3_seg23 dst3_seg23_res dst3_seg24 3.570000e-11
c_lev2_src2_dst3_seg23 dst3_seg24 0 7.000000e-15

r_lev2_src2_dst3_seg24 dst3_seg24 dst3_seg24_res 1.785000e-01
l_lev2_src2_dst3_seg24 dst3_seg24_res dst3_seg25 3.570000e-11
c_lev2_src2_dst3_seg24 dst3_seg25 0 7.000000e-15

r_lev2_src2_dst3_seg25 dst3_seg25 dst3_seg25_res 1.785000e-01
l_lev2_src2_dst3_seg25 dst3_seg25_res dst3_seg26 3.570000e-11
c_lev2_src2_dst3_seg25 dst3_seg26 0 7.000000e-15

r_lev2_src2_dst3_seg26 dst3_seg26 dst3_seg26_res 1.785000e-01
l_lev2_src2_dst3_seg26 dst3_seg26_res dst3_seg27 3.570000e-11
c_lev2_src2_dst3_seg26 dst3_seg27 0 7.000000e-15

r_lev2_src2_dst3_seg27 dst3_seg27 dst3_seg27_res 1.785000e-01
l_lev2_src2_dst3_seg27 dst3_seg27_res dst3_seg28 3.570000e-11
c_lev2_src2_dst3_seg27 dst3_seg28 0 7.000000e-15

r_lev2_src2_dst3_seg28 dst3_seg28 dst3_seg28_res 1.785000e-01
l_lev2_src2_dst3_seg28 dst3_seg28_res dst3_seg29 3.570000e-11
c_lev2_src2_dst3_seg28 dst3_seg29 0 7.000000e-15

r_lev2_src2_dst3_seg29 dst3_seg29 dst3_seg29_res 1.785000e-01
l_lev2_src2_dst3_seg29 dst3_seg29_res dst3_seg30 3.570000e-11
c_lev2_src2_dst3_seg29 dst3_seg30 0 7.000000e-15

r_lev2_src2_dst3_seg30 dst3_seg30 dst3_seg30_res 1.785000e-01
l_lev2_src2_dst3_seg30 dst3_seg30_res dst3_seg31 3.570000e-11
c_lev2_src2_dst3_seg30 dst3_seg31 0 7.000000e-15

r_lev2_src2_dst3_seg31 dst3_seg31 dst3_seg31_res 1.785000e-01
l_lev2_src2_dst3_seg31 dst3_seg31_res dst3_seg32 3.570000e-11
c_lev2_src2_dst3_seg31 dst3_seg32 0 7.000000e-15

r_lev2_src2_dst3_seg32 dst3_seg32 dst3_seg32_res 1.785000e-01
l_lev2_src2_dst3_seg32 dst3_seg32_res dst3_seg33 3.570000e-11
c_lev2_src2_dst3_seg32 dst3_seg33 0 7.000000e-15

r_lev2_src2_dst3_seg33 dst3_seg33 dst3_seg33_res 1.785000e-01
l_lev2_src2_dst3_seg33 dst3_seg33_res dst3_seg34 3.570000e-11
c_lev2_src2_dst3_seg33 dst3_seg34 0 7.000000e-15

r_lev2_src2_dst3_seg34 dst3_seg34 dst3_seg34_res 1.785000e-01
l_lev2_src2_dst3_seg34 dst3_seg34_res dst3_seg35 3.570000e-11
c_lev2_src2_dst3_seg34 dst3_seg35 0 7.000000e-15

r_lev2_src2_dst3_seg35 dst3_seg35 dst3_seg35_res 1.785000e-01
l_lev2_src2_dst3_seg35 dst3_seg35_res dst3_seg36 3.570000e-11
c_lev2_src2_dst3_seg35 dst3_seg36 0 7.000000e-15

r_lev2_src2_dst3_seg36 dst3_seg36 dst3_seg36_res 1.785000e-01
l_lev2_src2_dst3_seg36 dst3_seg36_res dst3_seg37 3.570000e-11
c_lev2_src2_dst3_seg36 dst3_seg37 0 7.000000e-15

r_lev2_src2_dst3_seg37 dst3_seg37 dst3_seg37_res 1.785000e-01
l_lev2_src2_dst3_seg37 dst3_seg37_res dst3_seg38 3.570000e-11
c_lev2_src2_dst3_seg37 dst3_seg38 0 7.000000e-15

r_lev2_src2_dst3_seg38 dst3_seg38 dst3_seg38_res 1.785000e-01
l_lev2_src2_dst3_seg38 dst3_seg38_res dst3_seg39 3.570000e-11
c_lev2_src2_dst3_seg38 dst3_seg39 0 7.000000e-15

r_lev2_src2_dst3_seg39 dst3_seg39 dst3_seg39_res 1.785000e-01
l_lev2_src2_dst3_seg39 dst3_seg39_res dst3_seg40 3.570000e-11
c_lev2_src2_dst3_seg39 dst3_seg40 0 7.000000e-15

r_lev2_src2_dst3_seg40 dst3_seg40 dst3_seg40_res 1.785000e-01
l_lev2_src2_dst3_seg40 dst3_seg40_res dst3_seg41 3.570000e-11
c_lev2_src2_dst3_seg40 dst3_seg41 0 7.000000e-15

r_lev2_src2_dst3_seg41 dst3_seg41 dst3_seg41_res 1.785000e-01
l_lev2_src2_dst3_seg41 dst3_seg41_res dst3_seg42 3.570000e-11
c_lev2_src2_dst3_seg41 dst3_seg42 0 7.000000e-15

r_lev2_src2_dst3_seg42 dst3_seg42 dst3_seg42_res 1.785000e-01
l_lev2_src2_dst3_seg42 dst3_seg42_res dst3_seg43 3.570000e-11
c_lev2_src2_dst3_seg42 dst3_seg43 0 7.000000e-15

r_lev2_src2_dst3_seg43 dst3_seg43 dst3_seg43_res 1.785000e-01
l_lev2_src2_dst3_seg43 dst3_seg43_res dst3_seg44 3.570000e-11
c_lev2_src2_dst3_seg43 dst3_seg44 0 7.000000e-15

r_lev2_src2_dst3_seg44 dst3_seg44 dst3_seg44_res 1.785000e-01
l_lev2_src2_dst3_seg44 dst3_seg44_res dst3_seg45 3.570000e-11
c_lev2_src2_dst3_seg44 dst3_seg45 0 7.000000e-15

r_lev2_src2_dst3_seg45 dst3_seg45 dst3_seg45_res 1.785000e-01
l_lev2_src2_dst3_seg45 dst3_seg45_res dst3_seg46 3.570000e-11
c_lev2_src2_dst3_seg45 dst3_seg46 0 7.000000e-15

r_lev2_src2_dst3_seg46 dst3_seg46 dst3_seg46_res 1.785000e-01
l_lev2_src2_dst3_seg46 dst3_seg46_res dst3_seg47 3.570000e-11
c_lev2_src2_dst3_seg46 dst3_seg47 0 7.000000e-15

r_lev2_src2_dst3_seg47 dst3_seg47 dst3_seg47_res 1.785000e-01
l_lev2_src2_dst3_seg47 dst3_seg47_res dst3_seg48 3.570000e-11
c_lev2_src2_dst3_seg47 dst3_seg48 0 7.000000e-15

r_lev2_src2_dst3_seg48 dst3_seg48 dst3_seg48_res 1.785000e-01
l_lev2_src2_dst3_seg48 dst3_seg48_res dst3_seg49 3.570000e-11
c_lev2_src2_dst3_seg48 dst3_seg49 0 7.000000e-15

r_lev2_src2_dst3_seg49 dst3_seg49 dst3_seg49_res 1.785000e-01
l_lev2_src2_dst3_seg49 dst3_seg49_res dst3_seg50 3.570000e-11
c_lev2_src2_dst3_seg49 dst3_seg50 0 7.000000e-15

r_lev2_src2_dst3_seg50 dst3_seg50 dst3_seg50_res 1.785000e-01
l_lev2_src2_dst3_seg50 dst3_seg50_res dst3_seg51 3.570000e-11
c_lev2_src2_dst3_seg50 dst3_seg51 0 7.000000e-15

r_lev2_src2_dst3_seg51 dst3_seg51 dst3_seg51_res 1.785000e-01
l_lev2_src2_dst3_seg51 dst3_seg51_res dst3_seg52 3.570000e-11
c_lev2_src2_dst3_seg51 dst3_seg52 0 7.000000e-15

r_lev2_src2_dst3_seg52 dst3_seg52 dst3_seg52_res 1.785000e-01
l_lev2_src2_dst3_seg52 dst3_seg52_res dst3_seg53 3.570000e-11
c_lev2_src2_dst3_seg52 dst3_seg53 0 7.000000e-15

r_lev2_src2_dst3_seg53 dst3_seg53 dst3_seg53_res 1.785000e-01
l_lev2_src2_dst3_seg53 dst3_seg53_res dst3_seg54 3.570000e-11
c_lev2_src2_dst3_seg53 dst3_seg54 0 7.000000e-15

r_lev2_src2_dst3_seg54 dst3_seg54 dst3_seg54_res 1.785000e-01
l_lev2_src2_dst3_seg54 dst3_seg54_res dst3_seg55 3.570000e-11
c_lev2_src2_dst3_seg54 dst3_seg55 0 7.000000e-15

r_lev2_src2_dst3_seg55 dst3_seg55 dst3_seg55_res 1.785000e-01
l_lev2_src2_dst3_seg55 dst3_seg55_res dst3_seg56 3.570000e-11
c_lev2_src2_dst3_seg55 dst3_seg56 0 7.000000e-15

r_lev2_src2_dst3_seg56 dst3_seg56 dst3_seg56_res 1.785000e-01
l_lev2_src2_dst3_seg56 dst3_seg56_res dst3_seg57 3.570000e-11
c_lev2_src2_dst3_seg56 dst3_seg57 0 7.000000e-15

r_lev2_src2_dst3_seg57 dst3_seg57 dst3_seg57_res 1.785000e-01
l_lev2_src2_dst3_seg57 dst3_seg57_res dst3_seg58 3.570000e-11
c_lev2_src2_dst3_seg57 dst3_seg58 0 7.000000e-15

r_lev2_src2_dst3_seg58 dst3_seg58 dst3_seg58_res 1.785000e-01
l_lev2_src2_dst3_seg58 dst3_seg58_res dst3_seg59 3.570000e-11
c_lev2_src2_dst3_seg58 dst3_seg59 0 7.000000e-15

r_lev2_src2_dst3_seg59 dst3_seg59 dst3_seg59_res 1.785000e-01
l_lev2_src2_dst3_seg59 dst3_seg59_res dst3_seg60 3.570000e-11
c_lev2_src2_dst3_seg59 dst3_seg60 0 7.000000e-15

r_lev2_src2_dst3_seg60 dst3_seg60 dst3_seg60_res 1.785000e-01
l_lev2_src2_dst3_seg60 dst3_seg60_res dst3_seg61 3.570000e-11
c_lev2_src2_dst3_seg60 dst3_seg61 0 7.000000e-15

r_lev2_src2_dst3_seg61 dst3_seg61 dst3_seg61_res 1.785000e-01
l_lev2_src2_dst3_seg61 dst3_seg61_res dst3_seg62 3.570000e-11
c_lev2_src2_dst3_seg61 dst3_seg62 0 7.000000e-15

r_lev2_src2_dst3_seg62 dst3_seg62 dst3_seg62_res 1.785000e-01
l_lev2_src2_dst3_seg62 dst3_seg62_res dst3_seg63 3.570000e-11
c_lev2_src2_dst3_seg62 dst3_seg63 0 7.000000e-15

r_lev2_src2_dst3_seg63 dst3_seg63 dst3_seg63_res 1.785000e-01
l_lev2_src2_dst3_seg63 dst3_seg63_res dst3_seg64 3.570000e-11
c_lev2_src2_dst3_seg63 dst3_seg64 0 7.000000e-15

r_lev2_src2_dst3_seg64 dst3_seg64 dst3_seg64_res 1.785000e-01
l_lev2_src2_dst3_seg64 dst3_seg64_res dst3_seg65 3.570000e-11
c_lev2_src2_dst3_seg64 dst3_seg65 0 7.000000e-15

r_lev2_src2_dst3_seg65 dst3_seg65 dst3_seg65_res 1.785000e-01
l_lev2_src2_dst3_seg65 dst3_seg65_res dst3_seg66 3.570000e-11
c_lev2_src2_dst3_seg65 dst3_seg66 0 7.000000e-15

r_lev2_src2_dst3_seg66 dst3_seg66 dst3_seg66_res 1.785000e-01
l_lev2_src2_dst3_seg66 dst3_seg66_res dst3_seg67 3.570000e-11
c_lev2_src2_dst3_seg66 dst3_seg67 0 7.000000e-15

r_lev2_src2_dst3_seg67 dst3_seg67 dst3_seg67_res 1.785000e-01
l_lev2_src2_dst3_seg67 dst3_seg67_res dst3_seg68 3.570000e-11
c_lev2_src2_dst3_seg67 dst3_seg68 0 7.000000e-15

r_lev2_src2_dst3_seg68 dst3_seg68 dst3_seg68_res 1.785000e-01
l_lev2_src2_dst3_seg68 dst3_seg68_res dst3_seg69 3.570000e-11
c_lev2_src2_dst3_seg68 dst3_seg69 0 7.000000e-15

r_lev2_src2_dst3_seg69 dst3_seg69 dst3_seg69_res 1.785000e-01
l_lev2_src2_dst3_seg69 dst3_seg69_res dst3_seg70 3.570000e-11
c_lev2_src2_dst3_seg69 dst3_seg70 0 7.000000e-15

r_lev2_src2_dst3_seg70 dst3_seg70 dst3_seg70_res 1.785000e-01
l_lev2_src2_dst3_seg70 dst3_seg70_res dst3_seg71 3.570000e-11
c_lev2_src2_dst3_seg70 dst3_seg71 0 7.000000e-15

r_lev2_src2_dst3_seg71 dst3_seg71 dst3_seg71_res 1.785000e-01
l_lev2_src2_dst3_seg71 dst3_seg71_res dst3_seg72 3.570000e-11
c_lev2_src2_dst3_seg71 dst3_seg72 0 7.000000e-15

r_lev2_src2_dst3_seg72 dst3_seg72 dst3_seg72_res 1.785000e-01
l_lev2_src2_dst3_seg72 dst3_seg72_res dst3_seg73 3.570000e-11
c_lev2_src2_dst3_seg72 dst3_seg73 0 7.000000e-15

r_lev2_src2_dst3_seg73 dst3_seg73 dst3_seg73_res 1.785000e-01
l_lev2_src2_dst3_seg73 dst3_seg73_res dst3_seg74 3.570000e-11
c_lev2_src2_dst3_seg73 dst3_seg74 0 7.000000e-15

r_lev2_src2_dst3_seg74 dst3_seg74 dst3_seg74_res 1.785000e-01
l_lev2_src2_dst3_seg74 dst3_seg74_res dst3_seg75 3.570000e-11
c_lev2_src2_dst3_seg74 dst3_seg75 0 7.000000e-15

r_lev2_src2_dst3_seg75 dst3_seg75 dst3_seg75_res 1.785000e-01
l_lev2_src2_dst3_seg75 dst3_seg75_res dst3_seg76 3.570000e-11
c_lev2_src2_dst3_seg75 dst3_seg76 0 7.000000e-15

r_lev2_src2_dst3_seg76 dst3_seg76 dst3_seg76_res 1.785000e-01
l_lev2_src2_dst3_seg76 dst3_seg76_res dst3_seg77 3.570000e-11
c_lev2_src2_dst3_seg76 dst3_seg77 0 7.000000e-15

r_lev2_src2_dst3_seg77 dst3_seg77 dst3_seg77_res 1.785000e-01
l_lev2_src2_dst3_seg77 dst3_seg77_res dst3_seg78 3.570000e-11
c_lev2_src2_dst3_seg77 dst3_seg78 0 7.000000e-15

r_lev2_src2_dst3_seg78 dst3_seg78 dst3_seg78_res 1.785000e-01
l_lev2_src2_dst3_seg78 dst3_seg78_res dst3_seg79 3.570000e-11
c_lev2_src2_dst3_seg78 dst3_seg79 0 7.000000e-15

r_lev2_src2_dst3_seg79 dst3_seg79 dst3_seg79_res 1.785000e-01
l_lev2_src2_dst3_seg79 dst3_seg79_res dst3_seg80 3.570000e-11
c_lev2_src2_dst3_seg79 dst3_seg80 0 7.000000e-15

r_lev2_src2_dst3_seg80 dst3_seg80 dst3_seg80_res 1.785000e-01
l_lev2_src2_dst3_seg80 dst3_seg80_res pt3 3.570000e-11
c_lev2_src2_dst3_seg80 pt3 0 7.000000e-15

r_lev2_src2_dst4_seg1 pt2 dst4_seg1_res 1.785000e-01
l_lev2_src2_dst4_seg1 dst4_seg1_res dst4_seg2 3.570000e-11
c_lev2_src2_dst4_seg1 dst4_seg2 0 7.000000e-15

r_lev2_src2_dst4_seg2 dst4_seg2 dst4_seg2_res 1.785000e-01
l_lev2_src2_dst4_seg2 dst4_seg2_res dst4_seg3 3.570000e-11
c_lev2_src2_dst4_seg2 dst4_seg3 0 7.000000e-15

r_lev2_src2_dst4_seg3 dst4_seg3 dst4_seg3_res 1.785000e-01
l_lev2_src2_dst4_seg3 dst4_seg3_res dst4_seg4 3.570000e-11
c_lev2_src2_dst4_seg3 dst4_seg4 0 7.000000e-15

r_lev2_src2_dst4_seg4 dst4_seg4 dst4_seg4_res 1.785000e-01
l_lev2_src2_dst4_seg4 dst4_seg4_res dst4_seg5 3.570000e-11
c_lev2_src2_dst4_seg4 dst4_seg5 0 7.000000e-15

r_lev2_src2_dst4_seg5 dst4_seg5 dst4_seg5_res 1.785000e-01
l_lev2_src2_dst4_seg5 dst4_seg5_res dst4_seg6 3.570000e-11
c_lev2_src2_dst4_seg5 dst4_seg6 0 7.000000e-15

r_lev2_src2_dst4_seg6 dst4_seg6 dst4_seg6_res 1.785000e-01
l_lev2_src2_dst4_seg6 dst4_seg6_res dst4_seg7 3.570000e-11
c_lev2_src2_dst4_seg6 dst4_seg7 0 7.000000e-15

r_lev2_src2_dst4_seg7 dst4_seg7 dst4_seg7_res 1.785000e-01
l_lev2_src2_dst4_seg7 dst4_seg7_res dst4_seg8 3.570000e-11
c_lev2_src2_dst4_seg7 dst4_seg8 0 7.000000e-15

r_lev2_src2_dst4_seg8 dst4_seg8 dst4_seg8_res 1.785000e-01
l_lev2_src2_dst4_seg8 dst4_seg8_res dst4_seg9 3.570000e-11
c_lev2_src2_dst4_seg8 dst4_seg9 0 7.000000e-15

r_lev2_src2_dst4_seg9 dst4_seg9 dst4_seg9_res 1.785000e-01
l_lev2_src2_dst4_seg9 dst4_seg9_res dst4_seg10 3.570000e-11
c_lev2_src2_dst4_seg9 dst4_seg10 0 7.000000e-15

r_lev2_src2_dst4_seg10 dst4_seg10 dst4_seg10_res 1.785000e-01
l_lev2_src2_dst4_seg10 dst4_seg10_res dst4_seg11 3.570000e-11
c_lev2_src2_dst4_seg10 dst4_seg11 0 7.000000e-15

r_lev2_src2_dst4_seg11 dst4_seg11 dst4_seg11_res 1.785000e-01
l_lev2_src2_dst4_seg11 dst4_seg11_res dst4_seg12 3.570000e-11
c_lev2_src2_dst4_seg11 dst4_seg12 0 7.000000e-15

r_lev2_src2_dst4_seg12 dst4_seg12 dst4_seg12_res 1.785000e-01
l_lev2_src2_dst4_seg12 dst4_seg12_res dst4_seg13 3.570000e-11
c_lev2_src2_dst4_seg12 dst4_seg13 0 7.000000e-15

r_lev2_src2_dst4_seg13 dst4_seg13 dst4_seg13_res 1.785000e-01
l_lev2_src2_dst4_seg13 dst4_seg13_res dst4_seg14 3.570000e-11
c_lev2_src2_dst4_seg13 dst4_seg14 0 7.000000e-15

r_lev2_src2_dst4_seg14 dst4_seg14 dst4_seg14_res 1.785000e-01
l_lev2_src2_dst4_seg14 dst4_seg14_res dst4_seg15 3.570000e-11
c_lev2_src2_dst4_seg14 dst4_seg15 0 7.000000e-15

r_lev2_src2_dst4_seg15 dst4_seg15 dst4_seg15_res 1.785000e-01
l_lev2_src2_dst4_seg15 dst4_seg15_res dst4_seg16 3.570000e-11
c_lev2_src2_dst4_seg15 dst4_seg16 0 7.000000e-15

r_lev2_src2_dst4_seg16 dst4_seg16 dst4_seg16_res 1.785000e-01
l_lev2_src2_dst4_seg16 dst4_seg16_res dst4_seg17 3.570000e-11
c_lev2_src2_dst4_seg16 dst4_seg17 0 7.000000e-15

r_lev2_src2_dst4_seg17 dst4_seg17 dst4_seg17_res 1.785000e-01
l_lev2_src2_dst4_seg17 dst4_seg17_res dst4_seg18 3.570000e-11
c_lev2_src2_dst4_seg17 dst4_seg18 0 7.000000e-15

r_lev2_src2_dst4_seg18 dst4_seg18 dst4_seg18_res 1.785000e-01
l_lev2_src2_dst4_seg18 dst4_seg18_res dst4_seg19 3.570000e-11
c_lev2_src2_dst4_seg18 dst4_seg19 0 7.000000e-15

r_lev2_src2_dst4_seg19 dst4_seg19 dst4_seg19_res 1.785000e-01
l_lev2_src2_dst4_seg19 dst4_seg19_res dst4_seg20 3.570000e-11
c_lev2_src2_dst4_seg19 dst4_seg20 0 7.000000e-15

r_lev2_src2_dst4_seg20 dst4_seg20 dst4_seg20_res 1.785000e-01
l_lev2_src2_dst4_seg20 dst4_seg20_res dst4_seg21 3.570000e-11
c_lev2_src2_dst4_seg20 dst4_seg21 0 7.000000e-15

r_lev2_src2_dst4_seg21 dst4_seg21 dst4_seg21_res 1.785000e-01
l_lev2_src2_dst4_seg21 dst4_seg21_res dst4_seg22 3.570000e-11
c_lev2_src2_dst4_seg21 dst4_seg22 0 7.000000e-15

r_lev2_src2_dst4_seg22 dst4_seg22 dst4_seg22_res 1.785000e-01
l_lev2_src2_dst4_seg22 dst4_seg22_res dst4_seg23 3.570000e-11
c_lev2_src2_dst4_seg22 dst4_seg23 0 7.000000e-15

r_lev2_src2_dst4_seg23 dst4_seg23 dst4_seg23_res 1.785000e-01
l_lev2_src2_dst4_seg23 dst4_seg23_res dst4_seg24 3.570000e-11
c_lev2_src2_dst4_seg23 dst4_seg24 0 7.000000e-15

r_lev2_src2_dst4_seg24 dst4_seg24 dst4_seg24_res 1.785000e-01
l_lev2_src2_dst4_seg24 dst4_seg24_res dst4_seg25 3.570000e-11
c_lev2_src2_dst4_seg24 dst4_seg25 0 7.000000e-15

r_lev2_src2_dst4_seg25 dst4_seg25 dst4_seg25_res 1.785000e-01
l_lev2_src2_dst4_seg25 dst4_seg25_res dst4_seg26 3.570000e-11
c_lev2_src2_dst4_seg25 dst4_seg26 0 7.000000e-15

r_lev2_src2_dst4_seg26 dst4_seg26 dst4_seg26_res 1.785000e-01
l_lev2_src2_dst4_seg26 dst4_seg26_res dst4_seg27 3.570000e-11
c_lev2_src2_dst4_seg26 dst4_seg27 0 7.000000e-15

r_lev2_src2_dst4_seg27 dst4_seg27 dst4_seg27_res 1.785000e-01
l_lev2_src2_dst4_seg27 dst4_seg27_res dst4_seg28 3.570000e-11
c_lev2_src2_dst4_seg27 dst4_seg28 0 7.000000e-15

r_lev2_src2_dst4_seg28 dst4_seg28 dst4_seg28_res 1.785000e-01
l_lev2_src2_dst4_seg28 dst4_seg28_res dst4_seg29 3.570000e-11
c_lev2_src2_dst4_seg28 dst4_seg29 0 7.000000e-15

r_lev2_src2_dst4_seg29 dst4_seg29 dst4_seg29_res 1.785000e-01
l_lev2_src2_dst4_seg29 dst4_seg29_res dst4_seg30 3.570000e-11
c_lev2_src2_dst4_seg29 dst4_seg30 0 7.000000e-15

r_lev2_src2_dst4_seg30 dst4_seg30 dst4_seg30_res 1.785000e-01
l_lev2_src2_dst4_seg30 dst4_seg30_res dst4_seg31 3.570000e-11
c_lev2_src2_dst4_seg30 dst4_seg31 0 7.000000e-15

r_lev2_src2_dst4_seg31 dst4_seg31 dst4_seg31_res 1.785000e-01
l_lev2_src2_dst4_seg31 dst4_seg31_res dst4_seg32 3.570000e-11
c_lev2_src2_dst4_seg31 dst4_seg32 0 7.000000e-15

r_lev2_src2_dst4_seg32 dst4_seg32 dst4_seg32_res 1.785000e-01
l_lev2_src2_dst4_seg32 dst4_seg32_res dst4_seg33 3.570000e-11
c_lev2_src2_dst4_seg32 dst4_seg33 0 7.000000e-15

r_lev2_src2_dst4_seg33 dst4_seg33 dst4_seg33_res 1.785000e-01
l_lev2_src2_dst4_seg33 dst4_seg33_res dst4_seg34 3.570000e-11
c_lev2_src2_dst4_seg33 dst4_seg34 0 7.000000e-15

r_lev2_src2_dst4_seg34 dst4_seg34 dst4_seg34_res 1.785000e-01
l_lev2_src2_dst4_seg34 dst4_seg34_res dst4_seg35 3.570000e-11
c_lev2_src2_dst4_seg34 dst4_seg35 0 7.000000e-15

r_lev2_src2_dst4_seg35 dst4_seg35 dst4_seg35_res 1.785000e-01
l_lev2_src2_dst4_seg35 dst4_seg35_res dst4_seg36 3.570000e-11
c_lev2_src2_dst4_seg35 dst4_seg36 0 7.000000e-15

r_lev2_src2_dst4_seg36 dst4_seg36 dst4_seg36_res 1.785000e-01
l_lev2_src2_dst4_seg36 dst4_seg36_res dst4_seg37 3.570000e-11
c_lev2_src2_dst4_seg36 dst4_seg37 0 7.000000e-15

r_lev2_src2_dst4_seg37 dst4_seg37 dst4_seg37_res 1.785000e-01
l_lev2_src2_dst4_seg37 dst4_seg37_res dst4_seg38 3.570000e-11
c_lev2_src2_dst4_seg37 dst4_seg38 0 7.000000e-15

r_lev2_src2_dst4_seg38 dst4_seg38 dst4_seg38_res 1.785000e-01
l_lev2_src2_dst4_seg38 dst4_seg38_res dst4_seg39 3.570000e-11
c_lev2_src2_dst4_seg38 dst4_seg39 0 7.000000e-15

r_lev2_src2_dst4_seg39 dst4_seg39 dst4_seg39_res 1.785000e-01
l_lev2_src2_dst4_seg39 dst4_seg39_res dst4_seg40 3.570000e-11
c_lev2_src2_dst4_seg39 dst4_seg40 0 7.000000e-15

r_lev2_src2_dst4_seg40 dst4_seg40 dst4_seg40_res 1.785000e-01
l_lev2_src2_dst4_seg40 dst4_seg40_res dst4_seg41 3.570000e-11
c_lev2_src2_dst4_seg40 dst4_seg41 0 7.000000e-15

r_lev2_src2_dst4_seg41 dst4_seg41 dst4_seg41_res 1.785000e-01
l_lev2_src2_dst4_seg41 dst4_seg41_res dst4_seg42 3.570000e-11
c_lev2_src2_dst4_seg41 dst4_seg42 0 7.000000e-15

r_lev2_src2_dst4_seg42 dst4_seg42 dst4_seg42_res 1.785000e-01
l_lev2_src2_dst4_seg42 dst4_seg42_res dst4_seg43 3.570000e-11
c_lev2_src2_dst4_seg42 dst4_seg43 0 7.000000e-15

r_lev2_src2_dst4_seg43 dst4_seg43 dst4_seg43_res 1.785000e-01
l_lev2_src2_dst4_seg43 dst4_seg43_res dst4_seg44 3.570000e-11
c_lev2_src2_dst4_seg43 dst4_seg44 0 7.000000e-15

r_lev2_src2_dst4_seg44 dst4_seg44 dst4_seg44_res 1.785000e-01
l_lev2_src2_dst4_seg44 dst4_seg44_res dst4_seg45 3.570000e-11
c_lev2_src2_dst4_seg44 dst4_seg45 0 7.000000e-15

r_lev2_src2_dst4_seg45 dst4_seg45 dst4_seg45_res 1.785000e-01
l_lev2_src2_dst4_seg45 dst4_seg45_res dst4_seg46 3.570000e-11
c_lev2_src2_dst4_seg45 dst4_seg46 0 7.000000e-15

r_lev2_src2_dst4_seg46 dst4_seg46 dst4_seg46_res 1.785000e-01
l_lev2_src2_dst4_seg46 dst4_seg46_res dst4_seg47 3.570000e-11
c_lev2_src2_dst4_seg46 dst4_seg47 0 7.000000e-15

r_lev2_src2_dst4_seg47 dst4_seg47 dst4_seg47_res 1.785000e-01
l_lev2_src2_dst4_seg47 dst4_seg47_res dst4_seg48 3.570000e-11
c_lev2_src2_dst4_seg47 dst4_seg48 0 7.000000e-15

r_lev2_src2_dst4_seg48 dst4_seg48 dst4_seg48_res 1.785000e-01
l_lev2_src2_dst4_seg48 dst4_seg48_res dst4_seg49 3.570000e-11
c_lev2_src2_dst4_seg48 dst4_seg49 0 7.000000e-15

r_lev2_src2_dst4_seg49 dst4_seg49 dst4_seg49_res 1.785000e-01
l_lev2_src2_dst4_seg49 dst4_seg49_res dst4_seg50 3.570000e-11
c_lev2_src2_dst4_seg49 dst4_seg50 0 7.000000e-15

r_lev2_src2_dst4_seg50 dst4_seg50 dst4_seg50_res 1.785000e-01
l_lev2_src2_dst4_seg50 dst4_seg50_res dst4_seg51 3.570000e-11
c_lev2_src2_dst4_seg50 dst4_seg51 0 7.000000e-15

r_lev2_src2_dst4_seg51 dst4_seg51 dst4_seg51_res 1.785000e-01
l_lev2_src2_dst4_seg51 dst4_seg51_res dst4_seg52 3.570000e-11
c_lev2_src2_dst4_seg51 dst4_seg52 0 7.000000e-15

r_lev2_src2_dst4_seg52 dst4_seg52 dst4_seg52_res 1.785000e-01
l_lev2_src2_dst4_seg52 dst4_seg52_res dst4_seg53 3.570000e-11
c_lev2_src2_dst4_seg52 dst4_seg53 0 7.000000e-15

r_lev2_src2_dst4_seg53 dst4_seg53 dst4_seg53_res 1.785000e-01
l_lev2_src2_dst4_seg53 dst4_seg53_res dst4_seg54 3.570000e-11
c_lev2_src2_dst4_seg53 dst4_seg54 0 7.000000e-15

r_lev2_src2_dst4_seg54 dst4_seg54 dst4_seg54_res 1.785000e-01
l_lev2_src2_dst4_seg54 dst4_seg54_res dst4_seg55 3.570000e-11
c_lev2_src2_dst4_seg54 dst4_seg55 0 7.000000e-15

r_lev2_src2_dst4_seg55 dst4_seg55 dst4_seg55_res 1.785000e-01
l_lev2_src2_dst4_seg55 dst4_seg55_res dst4_seg56 3.570000e-11
c_lev2_src2_dst4_seg55 dst4_seg56 0 7.000000e-15

r_lev2_src2_dst4_seg56 dst4_seg56 dst4_seg56_res 1.785000e-01
l_lev2_src2_dst4_seg56 dst4_seg56_res dst4_seg57 3.570000e-11
c_lev2_src2_dst4_seg56 dst4_seg57 0 7.000000e-15

r_lev2_src2_dst4_seg57 dst4_seg57 dst4_seg57_res 1.785000e-01
l_lev2_src2_dst4_seg57 dst4_seg57_res dst4_seg58 3.570000e-11
c_lev2_src2_dst4_seg57 dst4_seg58 0 7.000000e-15

r_lev2_src2_dst4_seg58 dst4_seg58 dst4_seg58_res 1.785000e-01
l_lev2_src2_dst4_seg58 dst4_seg58_res dst4_seg59 3.570000e-11
c_lev2_src2_dst4_seg58 dst4_seg59 0 7.000000e-15

r_lev2_src2_dst4_seg59 dst4_seg59 dst4_seg59_res 1.785000e-01
l_lev2_src2_dst4_seg59 dst4_seg59_res dst4_seg60 3.570000e-11
c_lev2_src2_dst4_seg59 dst4_seg60 0 7.000000e-15

r_lev2_src2_dst4_seg60 dst4_seg60 dst4_seg60_res 1.785000e-01
l_lev2_src2_dst4_seg60 dst4_seg60_res dst4_seg61 3.570000e-11
c_lev2_src2_dst4_seg60 dst4_seg61 0 7.000000e-15

r_lev2_src2_dst4_seg61 dst4_seg61 dst4_seg61_res 1.785000e-01
l_lev2_src2_dst4_seg61 dst4_seg61_res dst4_seg62 3.570000e-11
c_lev2_src2_dst4_seg61 dst4_seg62 0 7.000000e-15

r_lev2_src2_dst4_seg62 dst4_seg62 dst4_seg62_res 1.785000e-01
l_lev2_src2_dst4_seg62 dst4_seg62_res dst4_seg63 3.570000e-11
c_lev2_src2_dst4_seg62 dst4_seg63 0 7.000000e-15

r_lev2_src2_dst4_seg63 dst4_seg63 dst4_seg63_res 1.785000e-01
l_lev2_src2_dst4_seg63 dst4_seg63_res dst4_seg64 3.570000e-11
c_lev2_src2_dst4_seg63 dst4_seg64 0 7.000000e-15

r_lev2_src2_dst4_seg64 dst4_seg64 dst4_seg64_res 1.785000e-01
l_lev2_src2_dst4_seg64 dst4_seg64_res dst4_seg65 3.570000e-11
c_lev2_src2_dst4_seg64 dst4_seg65 0 7.000000e-15

r_lev2_src2_dst4_seg65 dst4_seg65 dst4_seg65_res 1.785000e-01
l_lev2_src2_dst4_seg65 dst4_seg65_res dst4_seg66 3.570000e-11
c_lev2_src2_dst4_seg65 dst4_seg66 0 7.000000e-15

r_lev2_src2_dst4_seg66 dst4_seg66 dst4_seg66_res 1.785000e-01
l_lev2_src2_dst4_seg66 dst4_seg66_res dst4_seg67 3.570000e-11
c_lev2_src2_dst4_seg66 dst4_seg67 0 7.000000e-15

r_lev2_src2_dst4_seg67 dst4_seg67 dst4_seg67_res 1.785000e-01
l_lev2_src2_dst4_seg67 dst4_seg67_res dst4_seg68 3.570000e-11
c_lev2_src2_dst4_seg67 dst4_seg68 0 7.000000e-15

r_lev2_src2_dst4_seg68 dst4_seg68 dst4_seg68_res 1.785000e-01
l_lev2_src2_dst4_seg68 dst4_seg68_res dst4_seg69 3.570000e-11
c_lev2_src2_dst4_seg68 dst4_seg69 0 7.000000e-15

r_lev2_src2_dst4_seg69 dst4_seg69 dst4_seg69_res 1.785000e-01
l_lev2_src2_dst4_seg69 dst4_seg69_res dst4_seg70 3.570000e-11
c_lev2_src2_dst4_seg69 dst4_seg70 0 7.000000e-15

r_lev2_src2_dst4_seg70 dst4_seg70 dst4_seg70_res 1.785000e-01
l_lev2_src2_dst4_seg70 dst4_seg70_res dst4_seg71 3.570000e-11
c_lev2_src2_dst4_seg70 dst4_seg71 0 7.000000e-15

r_lev2_src2_dst4_seg71 dst4_seg71 dst4_seg71_res 1.785000e-01
l_lev2_src2_dst4_seg71 dst4_seg71_res dst4_seg72 3.570000e-11
c_lev2_src2_dst4_seg71 dst4_seg72 0 7.000000e-15

r_lev2_src2_dst4_seg72 dst4_seg72 dst4_seg72_res 1.785000e-01
l_lev2_src2_dst4_seg72 dst4_seg72_res dst4_seg73 3.570000e-11
c_lev2_src2_dst4_seg72 dst4_seg73 0 7.000000e-15

r_lev2_src2_dst4_seg73 dst4_seg73 dst4_seg73_res 1.785000e-01
l_lev2_src2_dst4_seg73 dst4_seg73_res dst4_seg74 3.570000e-11
c_lev2_src2_dst4_seg73 dst4_seg74 0 7.000000e-15

r_lev2_src2_dst4_seg74 dst4_seg74 dst4_seg74_res 1.785000e-01
l_lev2_src2_dst4_seg74 dst4_seg74_res dst4_seg75 3.570000e-11
c_lev2_src2_dst4_seg74 dst4_seg75 0 7.000000e-15

r_lev2_src2_dst4_seg75 dst4_seg75 dst4_seg75_res 1.785000e-01
l_lev2_src2_dst4_seg75 dst4_seg75_res dst4_seg76 3.570000e-11
c_lev2_src2_dst4_seg75 dst4_seg76 0 7.000000e-15

r_lev2_src2_dst4_seg76 dst4_seg76 dst4_seg76_res 1.785000e-01
l_lev2_src2_dst4_seg76 dst4_seg76_res dst4_seg77 3.570000e-11
c_lev2_src2_dst4_seg76 dst4_seg77 0 7.000000e-15

r_lev2_src2_dst4_seg77 dst4_seg77 dst4_seg77_res 1.785000e-01
l_lev2_src2_dst4_seg77 dst4_seg77_res dst4_seg78 3.570000e-11
c_lev2_src2_dst4_seg77 dst4_seg78 0 7.000000e-15

r_lev2_src2_dst4_seg78 dst4_seg78 dst4_seg78_res 1.785000e-01
l_lev2_src2_dst4_seg78 dst4_seg78_res dst4_seg79 3.570000e-11
c_lev2_src2_dst4_seg78 dst4_seg79 0 7.000000e-15

r_lev2_src2_dst4_seg79 dst4_seg79 dst4_seg79_res 1.785000e-01
l_lev2_src2_dst4_seg79 dst4_seg79_res dst4_seg80 3.570000e-11
c_lev2_src2_dst4_seg79 dst4_seg80 0 7.000000e-15

r_lev2_src2_dst4_seg80 dst4_seg80 dst4_seg80_res 1.785000e-01
l_lev2_src2_dst4_seg80 dst4_seg80_res pt4 3.570000e-11
c_lev2_src2_dst4_seg80 pt4 0 7.000000e-15

r_lev3_src3_dst5_seg1 pt3 dst5_seg1_res 2.550000e-01
l_lev3_src3_dst5_seg1 dst5_seg1_res dst5_seg2 5.100000e-11
c_lev3_src3_dst5_seg1 dst5_seg2 0 4.900000e-15

r_lev3_src3_dst5_seg2 dst5_seg2 dst5_seg2_res 2.550000e-01
l_lev3_src3_dst5_seg2 dst5_seg2_res dst5_seg3 5.100000e-11
c_lev3_src3_dst5_seg2 dst5_seg3 0 4.900000e-15

r_lev3_src3_dst5_seg3 dst5_seg3 dst5_seg3_res 2.550000e-01
l_lev3_src3_dst5_seg3 dst5_seg3_res dst5_seg4 5.100000e-11
c_lev3_src3_dst5_seg3 dst5_seg4 0 4.900000e-15

r_lev3_src3_dst5_seg4 dst5_seg4 dst5_seg4_res 2.550000e-01
l_lev3_src3_dst5_seg4 dst5_seg4_res dst5_seg5 5.100000e-11
c_lev3_src3_dst5_seg4 dst5_seg5 0 4.900000e-15

r_lev3_src3_dst5_seg5 dst5_seg5 dst5_seg5_res 2.550000e-01
l_lev3_src3_dst5_seg5 dst5_seg5_res dst5_seg6 5.100000e-11
c_lev3_src3_dst5_seg5 dst5_seg6 0 4.900000e-15

r_lev3_src3_dst5_seg6 dst5_seg6 dst5_seg6_res 2.550000e-01
l_lev3_src3_dst5_seg6 dst5_seg6_res dst5_seg7 5.100000e-11
c_lev3_src3_dst5_seg6 dst5_seg7 0 4.900000e-15

r_lev3_src3_dst5_seg7 dst5_seg7 dst5_seg7_res 2.550000e-01
l_lev3_src3_dst5_seg7 dst5_seg7_res dst5_seg8 5.100000e-11
c_lev3_src3_dst5_seg7 dst5_seg8 0 4.900000e-15

r_lev3_src3_dst5_seg8 dst5_seg8 dst5_seg8_res 2.550000e-01
l_lev3_src3_dst5_seg8 dst5_seg8_res dst5_seg9 5.100000e-11
c_lev3_src3_dst5_seg8 dst5_seg9 0 4.900000e-15

r_lev3_src3_dst5_seg9 dst5_seg9 dst5_seg9_res 2.550000e-01
l_lev3_src3_dst5_seg9 dst5_seg9_res dst5_seg10 5.100000e-11
c_lev3_src3_dst5_seg9 dst5_seg10 0 4.900000e-15

r_lev3_src3_dst5_seg10 dst5_seg10 dst5_seg10_res 2.550000e-01
l_lev3_src3_dst5_seg10 dst5_seg10_res dst5_seg11 5.100000e-11
c_lev3_src3_dst5_seg10 dst5_seg11 0 4.900000e-15

r_lev3_src3_dst5_seg11 dst5_seg11 dst5_seg11_res 2.550000e-01
l_lev3_src3_dst5_seg11 dst5_seg11_res dst5_seg12 5.100000e-11
c_lev3_src3_dst5_seg11 dst5_seg12 0 4.900000e-15

r_lev3_src3_dst5_seg12 dst5_seg12 dst5_seg12_res 2.550000e-01
l_lev3_src3_dst5_seg12 dst5_seg12_res dst5_seg13 5.100000e-11
c_lev3_src3_dst5_seg12 dst5_seg13 0 4.900000e-15

r_lev3_src3_dst5_seg13 dst5_seg13 dst5_seg13_res 2.550000e-01
l_lev3_src3_dst5_seg13 dst5_seg13_res dst5_seg14 5.100000e-11
c_lev3_src3_dst5_seg13 dst5_seg14 0 4.900000e-15

r_lev3_src3_dst5_seg14 dst5_seg14 dst5_seg14_res 2.550000e-01
l_lev3_src3_dst5_seg14 dst5_seg14_res dst5_seg15 5.100000e-11
c_lev3_src3_dst5_seg14 dst5_seg15 0 4.900000e-15

r_lev3_src3_dst5_seg15 dst5_seg15 dst5_seg15_res 2.550000e-01
l_lev3_src3_dst5_seg15 dst5_seg15_res dst5_seg16 5.100000e-11
c_lev3_src3_dst5_seg15 dst5_seg16 0 4.900000e-15

r_lev3_src3_dst5_seg16 dst5_seg16 dst5_seg16_res 2.550000e-01
l_lev3_src3_dst5_seg16 dst5_seg16_res dst5_seg17 5.100000e-11
c_lev3_src3_dst5_seg16 dst5_seg17 0 4.900000e-15

r_lev3_src3_dst5_seg17 dst5_seg17 dst5_seg17_res 2.550000e-01
l_lev3_src3_dst5_seg17 dst5_seg17_res dst5_seg18 5.100000e-11
c_lev3_src3_dst5_seg17 dst5_seg18 0 4.900000e-15

r_lev3_src3_dst5_seg18 dst5_seg18 dst5_seg18_res 2.550000e-01
l_lev3_src3_dst5_seg18 dst5_seg18_res dst5_seg19 5.100000e-11
c_lev3_src3_dst5_seg18 dst5_seg19 0 4.900000e-15

r_lev3_src3_dst5_seg19 dst5_seg19 dst5_seg19_res 2.550000e-01
l_lev3_src3_dst5_seg19 dst5_seg19_res dst5_seg20 5.100000e-11
c_lev3_src3_dst5_seg19 dst5_seg20 0 4.900000e-15

r_lev3_src3_dst5_seg20 dst5_seg20 dst5_seg20_res 2.550000e-01
l_lev3_src3_dst5_seg20 dst5_seg20_res dst5_seg21 5.100000e-11
c_lev3_src3_dst5_seg20 dst5_seg21 0 4.900000e-15

r_lev3_src3_dst5_seg21 dst5_seg21 dst5_seg21_res 2.550000e-01
l_lev3_src3_dst5_seg21 dst5_seg21_res dst5_seg22 5.100000e-11
c_lev3_src3_dst5_seg21 dst5_seg22 0 4.900000e-15

r_lev3_src3_dst5_seg22 dst5_seg22 dst5_seg22_res 2.550000e-01
l_lev3_src3_dst5_seg22 dst5_seg22_res dst5_seg23 5.100000e-11
c_lev3_src3_dst5_seg22 dst5_seg23 0 4.900000e-15

r_lev3_src3_dst5_seg23 dst5_seg23 dst5_seg23_res 2.550000e-01
l_lev3_src3_dst5_seg23 dst5_seg23_res dst5_seg24 5.100000e-11
c_lev3_src3_dst5_seg23 dst5_seg24 0 4.900000e-15

r_lev3_src3_dst5_seg24 dst5_seg24 dst5_seg24_res 2.550000e-01
l_lev3_src3_dst5_seg24 dst5_seg24_res dst5_seg25 5.100000e-11
c_lev3_src3_dst5_seg24 dst5_seg25 0 4.900000e-15

r_lev3_src3_dst5_seg25 dst5_seg25 dst5_seg25_res 2.550000e-01
l_lev3_src3_dst5_seg25 dst5_seg25_res dst5_seg26 5.100000e-11
c_lev3_src3_dst5_seg25 dst5_seg26 0 4.900000e-15

r_lev3_src3_dst5_seg26 dst5_seg26 dst5_seg26_res 2.550000e-01
l_lev3_src3_dst5_seg26 dst5_seg26_res dst5_seg27 5.100000e-11
c_lev3_src3_dst5_seg26 dst5_seg27 0 4.900000e-15

r_lev3_src3_dst5_seg27 dst5_seg27 dst5_seg27_res 2.550000e-01
l_lev3_src3_dst5_seg27 dst5_seg27_res dst5_seg28 5.100000e-11
c_lev3_src3_dst5_seg27 dst5_seg28 0 4.900000e-15

r_lev3_src3_dst5_seg28 dst5_seg28 dst5_seg28_res 2.550000e-01
l_lev3_src3_dst5_seg28 dst5_seg28_res dst5_seg29 5.100000e-11
c_lev3_src3_dst5_seg28 dst5_seg29 0 4.900000e-15

r_lev3_src3_dst5_seg29 dst5_seg29 dst5_seg29_res 2.550000e-01
l_lev3_src3_dst5_seg29 dst5_seg29_res dst5_seg30 5.100000e-11
c_lev3_src3_dst5_seg29 dst5_seg30 0 4.900000e-15

r_lev3_src3_dst5_seg30 dst5_seg30 dst5_seg30_res 2.550000e-01
l_lev3_src3_dst5_seg30 dst5_seg30_res dst5_seg31 5.100000e-11
c_lev3_src3_dst5_seg30 dst5_seg31 0 4.900000e-15

r_lev3_src3_dst5_seg31 dst5_seg31 dst5_seg31_res 2.550000e-01
l_lev3_src3_dst5_seg31 dst5_seg31_res dst5_seg32 5.100000e-11
c_lev3_src3_dst5_seg31 dst5_seg32 0 4.900000e-15

r_lev3_src3_dst5_seg32 dst5_seg32 dst5_seg32_res 2.550000e-01
l_lev3_src3_dst5_seg32 dst5_seg32_res dst5_seg33 5.100000e-11
c_lev3_src3_dst5_seg32 dst5_seg33 0 4.900000e-15

r_lev3_src3_dst5_seg33 dst5_seg33 dst5_seg33_res 2.550000e-01
l_lev3_src3_dst5_seg33 dst5_seg33_res dst5_seg34 5.100000e-11
c_lev3_src3_dst5_seg33 dst5_seg34 0 4.900000e-15

r_lev3_src3_dst5_seg34 dst5_seg34 dst5_seg34_res 2.550000e-01
l_lev3_src3_dst5_seg34 dst5_seg34_res dst5_seg35 5.100000e-11
c_lev3_src3_dst5_seg34 dst5_seg35 0 4.900000e-15

r_lev3_src3_dst5_seg35 dst5_seg35 dst5_seg35_res 2.550000e-01
l_lev3_src3_dst5_seg35 dst5_seg35_res dst5_seg36 5.100000e-11
c_lev3_src3_dst5_seg35 dst5_seg36 0 4.900000e-15

r_lev3_src3_dst5_seg36 dst5_seg36 dst5_seg36_res 2.550000e-01
l_lev3_src3_dst5_seg36 dst5_seg36_res dst5_seg37 5.100000e-11
c_lev3_src3_dst5_seg36 dst5_seg37 0 4.900000e-15

r_lev3_src3_dst5_seg37 dst5_seg37 dst5_seg37_res 2.550000e-01
l_lev3_src3_dst5_seg37 dst5_seg37_res dst5_seg38 5.100000e-11
c_lev3_src3_dst5_seg37 dst5_seg38 0 4.900000e-15

r_lev3_src3_dst5_seg38 dst5_seg38 dst5_seg38_res 2.550000e-01
l_lev3_src3_dst5_seg38 dst5_seg38_res dst5_seg39 5.100000e-11
c_lev3_src3_dst5_seg38 dst5_seg39 0 4.900000e-15

r_lev3_src3_dst5_seg39 dst5_seg39 dst5_seg39_res 2.550000e-01
l_lev3_src3_dst5_seg39 dst5_seg39_res dst5_seg40 5.100000e-11
c_lev3_src3_dst5_seg39 dst5_seg40 0 4.900000e-15

r_lev3_src3_dst5_seg40 dst5_seg40 dst5_seg40_res 2.550000e-01
l_lev3_src3_dst5_seg40 dst5_seg40_res dst5_seg41 5.100000e-11
c_lev3_src3_dst5_seg40 dst5_seg41 0 4.900000e-15

r_lev3_src3_dst5_seg41 dst5_seg41 dst5_seg41_res 2.550000e-01
l_lev3_src3_dst5_seg41 dst5_seg41_res dst5_seg42 5.100000e-11
c_lev3_src3_dst5_seg41 dst5_seg42 0 4.900000e-15

r_lev3_src3_dst5_seg42 dst5_seg42 dst5_seg42_res 2.550000e-01
l_lev3_src3_dst5_seg42 dst5_seg42_res dst5_seg43 5.100000e-11
c_lev3_src3_dst5_seg42 dst5_seg43 0 4.900000e-15

r_lev3_src3_dst5_seg43 dst5_seg43 dst5_seg43_res 2.550000e-01
l_lev3_src3_dst5_seg43 dst5_seg43_res dst5_seg44 5.100000e-11
c_lev3_src3_dst5_seg43 dst5_seg44 0 4.900000e-15

r_lev3_src3_dst5_seg44 dst5_seg44 dst5_seg44_res 2.550000e-01
l_lev3_src3_dst5_seg44 dst5_seg44_res dst5_seg45 5.100000e-11
c_lev3_src3_dst5_seg44 dst5_seg45 0 4.900000e-15

r_lev3_src3_dst5_seg45 dst5_seg45 dst5_seg45_res 2.550000e-01
l_lev3_src3_dst5_seg45 dst5_seg45_res dst5_seg46 5.100000e-11
c_lev3_src3_dst5_seg45 dst5_seg46 0 4.900000e-15

r_lev3_src3_dst5_seg46 dst5_seg46 dst5_seg46_res 2.550000e-01
l_lev3_src3_dst5_seg46 dst5_seg46_res dst5_seg47 5.100000e-11
c_lev3_src3_dst5_seg46 dst5_seg47 0 4.900000e-15

r_lev3_src3_dst5_seg47 dst5_seg47 dst5_seg47_res 2.550000e-01
l_lev3_src3_dst5_seg47 dst5_seg47_res dst5_seg48 5.100000e-11
c_lev3_src3_dst5_seg47 dst5_seg48 0 4.900000e-15

r_lev3_src3_dst5_seg48 dst5_seg48 dst5_seg48_res 2.550000e-01
l_lev3_src3_dst5_seg48 dst5_seg48_res dst5_seg49 5.100000e-11
c_lev3_src3_dst5_seg48 dst5_seg49 0 4.900000e-15

r_lev3_src3_dst5_seg49 dst5_seg49 dst5_seg49_res 2.550000e-01
l_lev3_src3_dst5_seg49 dst5_seg49_res dst5_seg50 5.100000e-11
c_lev3_src3_dst5_seg49 dst5_seg50 0 4.900000e-15

r_lev3_src3_dst5_seg50 dst5_seg50 dst5_seg50_res 2.550000e-01
l_lev3_src3_dst5_seg50 dst5_seg50_res dst5_seg51 5.100000e-11
c_lev3_src3_dst5_seg50 dst5_seg51 0 4.900000e-15

r_lev3_src3_dst5_seg51 dst5_seg51 dst5_seg51_res 2.550000e-01
l_lev3_src3_dst5_seg51 dst5_seg51_res dst5_seg52 5.100000e-11
c_lev3_src3_dst5_seg51 dst5_seg52 0 4.900000e-15

r_lev3_src3_dst5_seg52 dst5_seg52 dst5_seg52_res 2.550000e-01
l_lev3_src3_dst5_seg52 dst5_seg52_res dst5_seg53 5.100000e-11
c_lev3_src3_dst5_seg52 dst5_seg53 0 4.900000e-15

r_lev3_src3_dst5_seg53 dst5_seg53 dst5_seg53_res 2.550000e-01
l_lev3_src3_dst5_seg53 dst5_seg53_res dst5_seg54 5.100000e-11
c_lev3_src3_dst5_seg53 dst5_seg54 0 4.900000e-15

r_lev3_src3_dst5_seg54 dst5_seg54 dst5_seg54_res 2.550000e-01
l_lev3_src3_dst5_seg54 dst5_seg54_res dst5_seg55 5.100000e-11
c_lev3_src3_dst5_seg54 dst5_seg55 0 4.900000e-15

r_lev3_src3_dst5_seg55 dst5_seg55 dst5_seg55_res 2.550000e-01
l_lev3_src3_dst5_seg55 dst5_seg55_res dst5_seg56 5.100000e-11
c_lev3_src3_dst5_seg55 dst5_seg56 0 4.900000e-15

r_lev3_src3_dst5_seg56 dst5_seg56 dst5_seg56_res 2.550000e-01
l_lev3_src3_dst5_seg56 dst5_seg56_res dst5_seg57 5.100000e-11
c_lev3_src3_dst5_seg56 dst5_seg57 0 4.900000e-15

r_lev3_src3_dst5_seg57 dst5_seg57 dst5_seg57_res 2.550000e-01
l_lev3_src3_dst5_seg57 dst5_seg57_res dst5_seg58 5.100000e-11
c_lev3_src3_dst5_seg57 dst5_seg58 0 4.900000e-15

r_lev3_src3_dst5_seg58 dst5_seg58 dst5_seg58_res 2.550000e-01
l_lev3_src3_dst5_seg58 dst5_seg58_res dst5_seg59 5.100000e-11
c_lev3_src3_dst5_seg58 dst5_seg59 0 4.900000e-15

r_lev3_src3_dst5_seg59 dst5_seg59 dst5_seg59_res 2.550000e-01
l_lev3_src3_dst5_seg59 dst5_seg59_res dst5_seg60 5.100000e-11
c_lev3_src3_dst5_seg59 dst5_seg60 0 4.900000e-15

r_lev3_src3_dst5_seg60 dst5_seg60 dst5_seg60_res 2.550000e-01
l_lev3_src3_dst5_seg60 dst5_seg60_res pt5 5.100000e-11
c_lev3_src3_dst5_seg60 pt5 0 4.900000e-15

r_lev3_src3_dst6_seg1 pt3 dst6_seg1_res 2.550000e-01
l_lev3_src3_dst6_seg1 dst6_seg1_res dst6_seg2 5.100000e-11
c_lev3_src3_dst6_seg1 dst6_seg2 0 4.900000e-15

r_lev3_src3_dst6_seg2 dst6_seg2 dst6_seg2_res 2.550000e-01
l_lev3_src3_dst6_seg2 dst6_seg2_res dst6_seg3 5.100000e-11
c_lev3_src3_dst6_seg2 dst6_seg3 0 4.900000e-15

r_lev3_src3_dst6_seg3 dst6_seg3 dst6_seg3_res 2.550000e-01
l_lev3_src3_dst6_seg3 dst6_seg3_res dst6_seg4 5.100000e-11
c_lev3_src3_dst6_seg3 dst6_seg4 0 4.900000e-15

r_lev3_src3_dst6_seg4 dst6_seg4 dst6_seg4_res 2.550000e-01
l_lev3_src3_dst6_seg4 dst6_seg4_res dst6_seg5 5.100000e-11
c_lev3_src3_dst6_seg4 dst6_seg5 0 4.900000e-15

r_lev3_src3_dst6_seg5 dst6_seg5 dst6_seg5_res 2.550000e-01
l_lev3_src3_dst6_seg5 dst6_seg5_res dst6_seg6 5.100000e-11
c_lev3_src3_dst6_seg5 dst6_seg6 0 4.900000e-15

r_lev3_src3_dst6_seg6 dst6_seg6 dst6_seg6_res 2.550000e-01
l_lev3_src3_dst6_seg6 dst6_seg6_res dst6_seg7 5.100000e-11
c_lev3_src3_dst6_seg6 dst6_seg7 0 4.900000e-15

r_lev3_src3_dst6_seg7 dst6_seg7 dst6_seg7_res 2.550000e-01
l_lev3_src3_dst6_seg7 dst6_seg7_res dst6_seg8 5.100000e-11
c_lev3_src3_dst6_seg7 dst6_seg8 0 4.900000e-15

r_lev3_src3_dst6_seg8 dst6_seg8 dst6_seg8_res 2.550000e-01
l_lev3_src3_dst6_seg8 dst6_seg8_res dst6_seg9 5.100000e-11
c_lev3_src3_dst6_seg8 dst6_seg9 0 4.900000e-15

r_lev3_src3_dst6_seg9 dst6_seg9 dst6_seg9_res 2.550000e-01
l_lev3_src3_dst6_seg9 dst6_seg9_res dst6_seg10 5.100000e-11
c_lev3_src3_dst6_seg9 dst6_seg10 0 4.900000e-15

r_lev3_src3_dst6_seg10 dst6_seg10 dst6_seg10_res 2.550000e-01
l_lev3_src3_dst6_seg10 dst6_seg10_res dst6_seg11 5.100000e-11
c_lev3_src3_dst6_seg10 dst6_seg11 0 4.900000e-15

r_lev3_src3_dst6_seg11 dst6_seg11 dst6_seg11_res 2.550000e-01
l_lev3_src3_dst6_seg11 dst6_seg11_res dst6_seg12 5.100000e-11
c_lev3_src3_dst6_seg11 dst6_seg12 0 4.900000e-15

r_lev3_src3_dst6_seg12 dst6_seg12 dst6_seg12_res 2.550000e-01
l_lev3_src3_dst6_seg12 dst6_seg12_res dst6_seg13 5.100000e-11
c_lev3_src3_dst6_seg12 dst6_seg13 0 4.900000e-15

r_lev3_src3_dst6_seg13 dst6_seg13 dst6_seg13_res 2.550000e-01
l_lev3_src3_dst6_seg13 dst6_seg13_res dst6_seg14 5.100000e-11
c_lev3_src3_dst6_seg13 dst6_seg14 0 4.900000e-15

r_lev3_src3_dst6_seg14 dst6_seg14 dst6_seg14_res 2.550000e-01
l_lev3_src3_dst6_seg14 dst6_seg14_res dst6_seg15 5.100000e-11
c_lev3_src3_dst6_seg14 dst6_seg15 0 4.900000e-15

r_lev3_src3_dst6_seg15 dst6_seg15 dst6_seg15_res 2.550000e-01
l_lev3_src3_dst6_seg15 dst6_seg15_res dst6_seg16 5.100000e-11
c_lev3_src3_dst6_seg15 dst6_seg16 0 4.900000e-15

r_lev3_src3_dst6_seg16 dst6_seg16 dst6_seg16_res 2.550000e-01
l_lev3_src3_dst6_seg16 dst6_seg16_res dst6_seg17 5.100000e-11
c_lev3_src3_dst6_seg16 dst6_seg17 0 4.900000e-15

r_lev3_src3_dst6_seg17 dst6_seg17 dst6_seg17_res 2.550000e-01
l_lev3_src3_dst6_seg17 dst6_seg17_res dst6_seg18 5.100000e-11
c_lev3_src3_dst6_seg17 dst6_seg18 0 4.900000e-15

r_lev3_src3_dst6_seg18 dst6_seg18 dst6_seg18_res 2.550000e-01
l_lev3_src3_dst6_seg18 dst6_seg18_res dst6_seg19 5.100000e-11
c_lev3_src3_dst6_seg18 dst6_seg19 0 4.900000e-15

r_lev3_src3_dst6_seg19 dst6_seg19 dst6_seg19_res 2.550000e-01
l_lev3_src3_dst6_seg19 dst6_seg19_res dst6_seg20 5.100000e-11
c_lev3_src3_dst6_seg19 dst6_seg20 0 4.900000e-15

r_lev3_src3_dst6_seg20 dst6_seg20 dst6_seg20_res 2.550000e-01
l_lev3_src3_dst6_seg20 dst6_seg20_res dst6_seg21 5.100000e-11
c_lev3_src3_dst6_seg20 dst6_seg21 0 4.900000e-15

r_lev3_src3_dst6_seg21 dst6_seg21 dst6_seg21_res 2.550000e-01
l_lev3_src3_dst6_seg21 dst6_seg21_res dst6_seg22 5.100000e-11
c_lev3_src3_dst6_seg21 dst6_seg22 0 4.900000e-15

r_lev3_src3_dst6_seg22 dst6_seg22 dst6_seg22_res 2.550000e-01
l_lev3_src3_dst6_seg22 dst6_seg22_res dst6_seg23 5.100000e-11
c_lev3_src3_dst6_seg22 dst6_seg23 0 4.900000e-15

r_lev3_src3_dst6_seg23 dst6_seg23 dst6_seg23_res 2.550000e-01
l_lev3_src3_dst6_seg23 dst6_seg23_res dst6_seg24 5.100000e-11
c_lev3_src3_dst6_seg23 dst6_seg24 0 4.900000e-15

r_lev3_src3_dst6_seg24 dst6_seg24 dst6_seg24_res 2.550000e-01
l_lev3_src3_dst6_seg24 dst6_seg24_res dst6_seg25 5.100000e-11
c_lev3_src3_dst6_seg24 dst6_seg25 0 4.900000e-15

r_lev3_src3_dst6_seg25 dst6_seg25 dst6_seg25_res 2.550000e-01
l_lev3_src3_dst6_seg25 dst6_seg25_res dst6_seg26 5.100000e-11
c_lev3_src3_dst6_seg25 dst6_seg26 0 4.900000e-15

r_lev3_src3_dst6_seg26 dst6_seg26 dst6_seg26_res 2.550000e-01
l_lev3_src3_dst6_seg26 dst6_seg26_res dst6_seg27 5.100000e-11
c_lev3_src3_dst6_seg26 dst6_seg27 0 4.900000e-15

r_lev3_src3_dst6_seg27 dst6_seg27 dst6_seg27_res 2.550000e-01
l_lev3_src3_dst6_seg27 dst6_seg27_res dst6_seg28 5.100000e-11
c_lev3_src3_dst6_seg27 dst6_seg28 0 4.900000e-15

r_lev3_src3_dst6_seg28 dst6_seg28 dst6_seg28_res 2.550000e-01
l_lev3_src3_dst6_seg28 dst6_seg28_res dst6_seg29 5.100000e-11
c_lev3_src3_dst6_seg28 dst6_seg29 0 4.900000e-15

r_lev3_src3_dst6_seg29 dst6_seg29 dst6_seg29_res 2.550000e-01
l_lev3_src3_dst6_seg29 dst6_seg29_res dst6_seg30 5.100000e-11
c_lev3_src3_dst6_seg29 dst6_seg30 0 4.900000e-15

r_lev3_src3_dst6_seg30 dst6_seg30 dst6_seg30_res 2.550000e-01
l_lev3_src3_dst6_seg30 dst6_seg30_res dst6_seg31 5.100000e-11
c_lev3_src3_dst6_seg30 dst6_seg31 0 4.900000e-15

r_lev3_src3_dst6_seg31 dst6_seg31 dst6_seg31_res 2.550000e-01
l_lev3_src3_dst6_seg31 dst6_seg31_res dst6_seg32 5.100000e-11
c_lev3_src3_dst6_seg31 dst6_seg32 0 4.900000e-15

r_lev3_src3_dst6_seg32 dst6_seg32 dst6_seg32_res 2.550000e-01
l_lev3_src3_dst6_seg32 dst6_seg32_res dst6_seg33 5.100000e-11
c_lev3_src3_dst6_seg32 dst6_seg33 0 4.900000e-15

r_lev3_src3_dst6_seg33 dst6_seg33 dst6_seg33_res 2.550000e-01
l_lev3_src3_dst6_seg33 dst6_seg33_res dst6_seg34 5.100000e-11
c_lev3_src3_dst6_seg33 dst6_seg34 0 4.900000e-15

r_lev3_src3_dst6_seg34 dst6_seg34 dst6_seg34_res 2.550000e-01
l_lev3_src3_dst6_seg34 dst6_seg34_res dst6_seg35 5.100000e-11
c_lev3_src3_dst6_seg34 dst6_seg35 0 4.900000e-15

r_lev3_src3_dst6_seg35 dst6_seg35 dst6_seg35_res 2.550000e-01
l_lev3_src3_dst6_seg35 dst6_seg35_res dst6_seg36 5.100000e-11
c_lev3_src3_dst6_seg35 dst6_seg36 0 4.900000e-15

r_lev3_src3_dst6_seg36 dst6_seg36 dst6_seg36_res 2.550000e-01
l_lev3_src3_dst6_seg36 dst6_seg36_res dst6_seg37 5.100000e-11
c_lev3_src3_dst6_seg36 dst6_seg37 0 4.900000e-15

r_lev3_src3_dst6_seg37 dst6_seg37 dst6_seg37_res 2.550000e-01
l_lev3_src3_dst6_seg37 dst6_seg37_res dst6_seg38 5.100000e-11
c_lev3_src3_dst6_seg37 dst6_seg38 0 4.900000e-15

r_lev3_src3_dst6_seg38 dst6_seg38 dst6_seg38_res 2.550000e-01
l_lev3_src3_dst6_seg38 dst6_seg38_res dst6_seg39 5.100000e-11
c_lev3_src3_dst6_seg38 dst6_seg39 0 4.900000e-15

r_lev3_src3_dst6_seg39 dst6_seg39 dst6_seg39_res 2.550000e-01
l_lev3_src3_dst6_seg39 dst6_seg39_res dst6_seg40 5.100000e-11
c_lev3_src3_dst6_seg39 dst6_seg40 0 4.900000e-15

r_lev3_src3_dst6_seg40 dst6_seg40 dst6_seg40_res 2.550000e-01
l_lev3_src3_dst6_seg40 dst6_seg40_res dst6_seg41 5.100000e-11
c_lev3_src3_dst6_seg40 dst6_seg41 0 4.900000e-15

r_lev3_src3_dst6_seg41 dst6_seg41 dst6_seg41_res 2.550000e-01
l_lev3_src3_dst6_seg41 dst6_seg41_res dst6_seg42 5.100000e-11
c_lev3_src3_dst6_seg41 dst6_seg42 0 4.900000e-15

r_lev3_src3_dst6_seg42 dst6_seg42 dst6_seg42_res 2.550000e-01
l_lev3_src3_dst6_seg42 dst6_seg42_res dst6_seg43 5.100000e-11
c_lev3_src3_dst6_seg42 dst6_seg43 0 4.900000e-15

r_lev3_src3_dst6_seg43 dst6_seg43 dst6_seg43_res 2.550000e-01
l_lev3_src3_dst6_seg43 dst6_seg43_res dst6_seg44 5.100000e-11
c_lev3_src3_dst6_seg43 dst6_seg44 0 4.900000e-15

r_lev3_src3_dst6_seg44 dst6_seg44 dst6_seg44_res 2.550000e-01
l_lev3_src3_dst6_seg44 dst6_seg44_res dst6_seg45 5.100000e-11
c_lev3_src3_dst6_seg44 dst6_seg45 0 4.900000e-15

r_lev3_src3_dst6_seg45 dst6_seg45 dst6_seg45_res 2.550000e-01
l_lev3_src3_dst6_seg45 dst6_seg45_res dst6_seg46 5.100000e-11
c_lev3_src3_dst6_seg45 dst6_seg46 0 4.900000e-15

r_lev3_src3_dst6_seg46 dst6_seg46 dst6_seg46_res 2.550000e-01
l_lev3_src3_dst6_seg46 dst6_seg46_res dst6_seg47 5.100000e-11
c_lev3_src3_dst6_seg46 dst6_seg47 0 4.900000e-15

r_lev3_src3_dst6_seg47 dst6_seg47 dst6_seg47_res 2.550000e-01
l_lev3_src3_dst6_seg47 dst6_seg47_res dst6_seg48 5.100000e-11
c_lev3_src3_dst6_seg47 dst6_seg48 0 4.900000e-15

r_lev3_src3_dst6_seg48 dst6_seg48 dst6_seg48_res 2.550000e-01
l_lev3_src3_dst6_seg48 dst6_seg48_res dst6_seg49 5.100000e-11
c_lev3_src3_dst6_seg48 dst6_seg49 0 4.900000e-15

r_lev3_src3_dst6_seg49 dst6_seg49 dst6_seg49_res 2.550000e-01
l_lev3_src3_dst6_seg49 dst6_seg49_res dst6_seg50 5.100000e-11
c_lev3_src3_dst6_seg49 dst6_seg50 0 4.900000e-15

r_lev3_src3_dst6_seg50 dst6_seg50 dst6_seg50_res 2.550000e-01
l_lev3_src3_dst6_seg50 dst6_seg50_res dst6_seg51 5.100000e-11
c_lev3_src3_dst6_seg50 dst6_seg51 0 4.900000e-15

r_lev3_src3_dst6_seg51 dst6_seg51 dst6_seg51_res 2.550000e-01
l_lev3_src3_dst6_seg51 dst6_seg51_res dst6_seg52 5.100000e-11
c_lev3_src3_dst6_seg51 dst6_seg52 0 4.900000e-15

r_lev3_src3_dst6_seg52 dst6_seg52 dst6_seg52_res 2.550000e-01
l_lev3_src3_dst6_seg52 dst6_seg52_res dst6_seg53 5.100000e-11
c_lev3_src3_dst6_seg52 dst6_seg53 0 4.900000e-15

r_lev3_src3_dst6_seg53 dst6_seg53 dst6_seg53_res 2.550000e-01
l_lev3_src3_dst6_seg53 dst6_seg53_res dst6_seg54 5.100000e-11
c_lev3_src3_dst6_seg53 dst6_seg54 0 4.900000e-15

r_lev3_src3_dst6_seg54 dst6_seg54 dst6_seg54_res 2.550000e-01
l_lev3_src3_dst6_seg54 dst6_seg54_res dst6_seg55 5.100000e-11
c_lev3_src3_dst6_seg54 dst6_seg55 0 4.900000e-15

r_lev3_src3_dst6_seg55 dst6_seg55 dst6_seg55_res 2.550000e-01
l_lev3_src3_dst6_seg55 dst6_seg55_res dst6_seg56 5.100000e-11
c_lev3_src3_dst6_seg55 dst6_seg56 0 4.900000e-15

r_lev3_src3_dst6_seg56 dst6_seg56 dst6_seg56_res 2.550000e-01
l_lev3_src3_dst6_seg56 dst6_seg56_res dst6_seg57 5.100000e-11
c_lev3_src3_dst6_seg56 dst6_seg57 0 4.900000e-15

r_lev3_src3_dst6_seg57 dst6_seg57 dst6_seg57_res 2.550000e-01
l_lev3_src3_dst6_seg57 dst6_seg57_res dst6_seg58 5.100000e-11
c_lev3_src3_dst6_seg57 dst6_seg58 0 4.900000e-15

r_lev3_src3_dst6_seg58 dst6_seg58 dst6_seg58_res 2.550000e-01
l_lev3_src3_dst6_seg58 dst6_seg58_res dst6_seg59 5.100000e-11
c_lev3_src3_dst6_seg58 dst6_seg59 0 4.900000e-15

r_lev3_src3_dst6_seg59 dst6_seg59 dst6_seg59_res 2.550000e-01
l_lev3_src3_dst6_seg59 dst6_seg59_res dst6_seg60 5.100000e-11
c_lev3_src3_dst6_seg59 dst6_seg60 0 4.900000e-15

r_lev3_src3_dst6_seg60 dst6_seg60 dst6_seg60_res 2.550000e-01
l_lev3_src3_dst6_seg60 dst6_seg60_res pt6 5.100000e-11
c_lev3_src3_dst6_seg60 pt6 0 4.900000e-15

r_lev3_src4_dst7_seg1 pt4 dst7_seg1_res 2.550000e-01
l_lev3_src4_dst7_seg1 dst7_seg1_res dst7_seg2 5.100000e-11
c_lev3_src4_dst7_seg1 dst7_seg2 0 4.900000e-15

r_lev3_src4_dst7_seg2 dst7_seg2 dst7_seg2_res 2.550000e-01
l_lev3_src4_dst7_seg2 dst7_seg2_res dst7_seg3 5.100000e-11
c_lev3_src4_dst7_seg2 dst7_seg3 0 4.900000e-15

r_lev3_src4_dst7_seg3 dst7_seg3 dst7_seg3_res 2.550000e-01
l_lev3_src4_dst7_seg3 dst7_seg3_res dst7_seg4 5.100000e-11
c_lev3_src4_dst7_seg3 dst7_seg4 0 4.900000e-15

r_lev3_src4_dst7_seg4 dst7_seg4 dst7_seg4_res 2.550000e-01
l_lev3_src4_dst7_seg4 dst7_seg4_res dst7_seg5 5.100000e-11
c_lev3_src4_dst7_seg4 dst7_seg5 0 4.900000e-15

r_lev3_src4_dst7_seg5 dst7_seg5 dst7_seg5_res 2.550000e-01
l_lev3_src4_dst7_seg5 dst7_seg5_res dst7_seg6 5.100000e-11
c_lev3_src4_dst7_seg5 dst7_seg6 0 4.900000e-15

r_lev3_src4_dst7_seg6 dst7_seg6 dst7_seg6_res 2.550000e-01
l_lev3_src4_dst7_seg6 dst7_seg6_res dst7_seg7 5.100000e-11
c_lev3_src4_dst7_seg6 dst7_seg7 0 4.900000e-15

r_lev3_src4_dst7_seg7 dst7_seg7 dst7_seg7_res 2.550000e-01
l_lev3_src4_dst7_seg7 dst7_seg7_res dst7_seg8 5.100000e-11
c_lev3_src4_dst7_seg7 dst7_seg8 0 4.900000e-15

r_lev3_src4_dst7_seg8 dst7_seg8 dst7_seg8_res 2.550000e-01
l_lev3_src4_dst7_seg8 dst7_seg8_res dst7_seg9 5.100000e-11
c_lev3_src4_dst7_seg8 dst7_seg9 0 4.900000e-15

r_lev3_src4_dst7_seg9 dst7_seg9 dst7_seg9_res 2.550000e-01
l_lev3_src4_dst7_seg9 dst7_seg9_res dst7_seg10 5.100000e-11
c_lev3_src4_dst7_seg9 dst7_seg10 0 4.900000e-15

r_lev3_src4_dst7_seg10 dst7_seg10 dst7_seg10_res 2.550000e-01
l_lev3_src4_dst7_seg10 dst7_seg10_res dst7_seg11 5.100000e-11
c_lev3_src4_dst7_seg10 dst7_seg11 0 4.900000e-15

r_lev3_src4_dst7_seg11 dst7_seg11 dst7_seg11_res 2.550000e-01
l_lev3_src4_dst7_seg11 dst7_seg11_res dst7_seg12 5.100000e-11
c_lev3_src4_dst7_seg11 dst7_seg12 0 4.900000e-15

r_lev3_src4_dst7_seg12 dst7_seg12 dst7_seg12_res 2.550000e-01
l_lev3_src4_dst7_seg12 dst7_seg12_res dst7_seg13 5.100000e-11
c_lev3_src4_dst7_seg12 dst7_seg13 0 4.900000e-15

r_lev3_src4_dst7_seg13 dst7_seg13 dst7_seg13_res 2.550000e-01
l_lev3_src4_dst7_seg13 dst7_seg13_res dst7_seg14 5.100000e-11
c_lev3_src4_dst7_seg13 dst7_seg14 0 4.900000e-15

r_lev3_src4_dst7_seg14 dst7_seg14 dst7_seg14_res 2.550000e-01
l_lev3_src4_dst7_seg14 dst7_seg14_res dst7_seg15 5.100000e-11
c_lev3_src4_dst7_seg14 dst7_seg15 0 4.900000e-15

r_lev3_src4_dst7_seg15 dst7_seg15 dst7_seg15_res 2.550000e-01
l_lev3_src4_dst7_seg15 dst7_seg15_res dst7_seg16 5.100000e-11
c_lev3_src4_dst7_seg15 dst7_seg16 0 4.900000e-15

r_lev3_src4_dst7_seg16 dst7_seg16 dst7_seg16_res 2.550000e-01
l_lev3_src4_dst7_seg16 dst7_seg16_res dst7_seg17 5.100000e-11
c_lev3_src4_dst7_seg16 dst7_seg17 0 4.900000e-15

r_lev3_src4_dst7_seg17 dst7_seg17 dst7_seg17_res 2.550000e-01
l_lev3_src4_dst7_seg17 dst7_seg17_res dst7_seg18 5.100000e-11
c_lev3_src4_dst7_seg17 dst7_seg18 0 4.900000e-15

r_lev3_src4_dst7_seg18 dst7_seg18 dst7_seg18_res 2.550000e-01
l_lev3_src4_dst7_seg18 dst7_seg18_res dst7_seg19 5.100000e-11
c_lev3_src4_dst7_seg18 dst7_seg19 0 4.900000e-15

r_lev3_src4_dst7_seg19 dst7_seg19 dst7_seg19_res 2.550000e-01
l_lev3_src4_dst7_seg19 dst7_seg19_res dst7_seg20 5.100000e-11
c_lev3_src4_dst7_seg19 dst7_seg20 0 4.900000e-15

r_lev3_src4_dst7_seg20 dst7_seg20 dst7_seg20_res 2.550000e-01
l_lev3_src4_dst7_seg20 dst7_seg20_res dst7_seg21 5.100000e-11
c_lev3_src4_dst7_seg20 dst7_seg21 0 4.900000e-15

r_lev3_src4_dst7_seg21 dst7_seg21 dst7_seg21_res 2.550000e-01
l_lev3_src4_dst7_seg21 dst7_seg21_res dst7_seg22 5.100000e-11
c_lev3_src4_dst7_seg21 dst7_seg22 0 4.900000e-15

r_lev3_src4_dst7_seg22 dst7_seg22 dst7_seg22_res 2.550000e-01
l_lev3_src4_dst7_seg22 dst7_seg22_res dst7_seg23 5.100000e-11
c_lev3_src4_dst7_seg22 dst7_seg23 0 4.900000e-15

r_lev3_src4_dst7_seg23 dst7_seg23 dst7_seg23_res 2.550000e-01
l_lev3_src4_dst7_seg23 dst7_seg23_res dst7_seg24 5.100000e-11
c_lev3_src4_dst7_seg23 dst7_seg24 0 4.900000e-15

r_lev3_src4_dst7_seg24 dst7_seg24 dst7_seg24_res 2.550000e-01
l_lev3_src4_dst7_seg24 dst7_seg24_res dst7_seg25 5.100000e-11
c_lev3_src4_dst7_seg24 dst7_seg25 0 4.900000e-15

r_lev3_src4_dst7_seg25 dst7_seg25 dst7_seg25_res 2.550000e-01
l_lev3_src4_dst7_seg25 dst7_seg25_res dst7_seg26 5.100000e-11
c_lev3_src4_dst7_seg25 dst7_seg26 0 4.900000e-15

r_lev3_src4_dst7_seg26 dst7_seg26 dst7_seg26_res 2.550000e-01
l_lev3_src4_dst7_seg26 dst7_seg26_res dst7_seg27 5.100000e-11
c_lev3_src4_dst7_seg26 dst7_seg27 0 4.900000e-15

r_lev3_src4_dst7_seg27 dst7_seg27 dst7_seg27_res 2.550000e-01
l_lev3_src4_dst7_seg27 dst7_seg27_res dst7_seg28 5.100000e-11
c_lev3_src4_dst7_seg27 dst7_seg28 0 4.900000e-15

r_lev3_src4_dst7_seg28 dst7_seg28 dst7_seg28_res 2.550000e-01
l_lev3_src4_dst7_seg28 dst7_seg28_res dst7_seg29 5.100000e-11
c_lev3_src4_dst7_seg28 dst7_seg29 0 4.900000e-15

r_lev3_src4_dst7_seg29 dst7_seg29 dst7_seg29_res 2.550000e-01
l_lev3_src4_dst7_seg29 dst7_seg29_res dst7_seg30 5.100000e-11
c_lev3_src4_dst7_seg29 dst7_seg30 0 4.900000e-15

r_lev3_src4_dst7_seg30 dst7_seg30 dst7_seg30_res 2.550000e-01
l_lev3_src4_dst7_seg30 dst7_seg30_res dst7_seg31 5.100000e-11
c_lev3_src4_dst7_seg30 dst7_seg31 0 4.900000e-15

r_lev3_src4_dst7_seg31 dst7_seg31 dst7_seg31_res 2.550000e-01
l_lev3_src4_dst7_seg31 dst7_seg31_res dst7_seg32 5.100000e-11
c_lev3_src4_dst7_seg31 dst7_seg32 0 4.900000e-15

r_lev3_src4_dst7_seg32 dst7_seg32 dst7_seg32_res 2.550000e-01
l_lev3_src4_dst7_seg32 dst7_seg32_res dst7_seg33 5.100000e-11
c_lev3_src4_dst7_seg32 dst7_seg33 0 4.900000e-15

r_lev3_src4_dst7_seg33 dst7_seg33 dst7_seg33_res 2.550000e-01
l_lev3_src4_dst7_seg33 dst7_seg33_res dst7_seg34 5.100000e-11
c_lev3_src4_dst7_seg33 dst7_seg34 0 4.900000e-15

r_lev3_src4_dst7_seg34 dst7_seg34 dst7_seg34_res 2.550000e-01
l_lev3_src4_dst7_seg34 dst7_seg34_res dst7_seg35 5.100000e-11
c_lev3_src4_dst7_seg34 dst7_seg35 0 4.900000e-15

r_lev3_src4_dst7_seg35 dst7_seg35 dst7_seg35_res 2.550000e-01
l_lev3_src4_dst7_seg35 dst7_seg35_res dst7_seg36 5.100000e-11
c_lev3_src4_dst7_seg35 dst7_seg36 0 4.900000e-15

r_lev3_src4_dst7_seg36 dst7_seg36 dst7_seg36_res 2.550000e-01
l_lev3_src4_dst7_seg36 dst7_seg36_res dst7_seg37 5.100000e-11
c_lev3_src4_dst7_seg36 dst7_seg37 0 4.900000e-15

r_lev3_src4_dst7_seg37 dst7_seg37 dst7_seg37_res 2.550000e-01
l_lev3_src4_dst7_seg37 dst7_seg37_res dst7_seg38 5.100000e-11
c_lev3_src4_dst7_seg37 dst7_seg38 0 4.900000e-15

r_lev3_src4_dst7_seg38 dst7_seg38 dst7_seg38_res 2.550000e-01
l_lev3_src4_dst7_seg38 dst7_seg38_res dst7_seg39 5.100000e-11
c_lev3_src4_dst7_seg38 dst7_seg39 0 4.900000e-15

r_lev3_src4_dst7_seg39 dst7_seg39 dst7_seg39_res 2.550000e-01
l_lev3_src4_dst7_seg39 dst7_seg39_res dst7_seg40 5.100000e-11
c_lev3_src4_dst7_seg39 dst7_seg40 0 4.900000e-15

r_lev3_src4_dst7_seg40 dst7_seg40 dst7_seg40_res 2.550000e-01
l_lev3_src4_dst7_seg40 dst7_seg40_res dst7_seg41 5.100000e-11
c_lev3_src4_dst7_seg40 dst7_seg41 0 4.900000e-15

r_lev3_src4_dst7_seg41 dst7_seg41 dst7_seg41_res 2.550000e-01
l_lev3_src4_dst7_seg41 dst7_seg41_res dst7_seg42 5.100000e-11
c_lev3_src4_dst7_seg41 dst7_seg42 0 4.900000e-15

r_lev3_src4_dst7_seg42 dst7_seg42 dst7_seg42_res 2.550000e-01
l_lev3_src4_dst7_seg42 dst7_seg42_res dst7_seg43 5.100000e-11
c_lev3_src4_dst7_seg42 dst7_seg43 0 4.900000e-15

r_lev3_src4_dst7_seg43 dst7_seg43 dst7_seg43_res 2.550000e-01
l_lev3_src4_dst7_seg43 dst7_seg43_res dst7_seg44 5.100000e-11
c_lev3_src4_dst7_seg43 dst7_seg44 0 4.900000e-15

r_lev3_src4_dst7_seg44 dst7_seg44 dst7_seg44_res 2.550000e-01
l_lev3_src4_dst7_seg44 dst7_seg44_res dst7_seg45 5.100000e-11
c_lev3_src4_dst7_seg44 dst7_seg45 0 4.900000e-15

r_lev3_src4_dst7_seg45 dst7_seg45 dst7_seg45_res 2.550000e-01
l_lev3_src4_dst7_seg45 dst7_seg45_res dst7_seg46 5.100000e-11
c_lev3_src4_dst7_seg45 dst7_seg46 0 4.900000e-15

r_lev3_src4_dst7_seg46 dst7_seg46 dst7_seg46_res 2.550000e-01
l_lev3_src4_dst7_seg46 dst7_seg46_res dst7_seg47 5.100000e-11
c_lev3_src4_dst7_seg46 dst7_seg47 0 4.900000e-15

r_lev3_src4_dst7_seg47 dst7_seg47 dst7_seg47_res 2.550000e-01
l_lev3_src4_dst7_seg47 dst7_seg47_res dst7_seg48 5.100000e-11
c_lev3_src4_dst7_seg47 dst7_seg48 0 4.900000e-15

r_lev3_src4_dst7_seg48 dst7_seg48 dst7_seg48_res 2.550000e-01
l_lev3_src4_dst7_seg48 dst7_seg48_res dst7_seg49 5.100000e-11
c_lev3_src4_dst7_seg48 dst7_seg49 0 4.900000e-15

r_lev3_src4_dst7_seg49 dst7_seg49 dst7_seg49_res 2.550000e-01
l_lev3_src4_dst7_seg49 dst7_seg49_res dst7_seg50 5.100000e-11
c_lev3_src4_dst7_seg49 dst7_seg50 0 4.900000e-15

r_lev3_src4_dst7_seg50 dst7_seg50 dst7_seg50_res 2.550000e-01
l_lev3_src4_dst7_seg50 dst7_seg50_res dst7_seg51 5.100000e-11
c_lev3_src4_dst7_seg50 dst7_seg51 0 4.900000e-15

r_lev3_src4_dst7_seg51 dst7_seg51 dst7_seg51_res 2.550000e-01
l_lev3_src4_dst7_seg51 dst7_seg51_res dst7_seg52 5.100000e-11
c_lev3_src4_dst7_seg51 dst7_seg52 0 4.900000e-15

r_lev3_src4_dst7_seg52 dst7_seg52 dst7_seg52_res 2.550000e-01
l_lev3_src4_dst7_seg52 dst7_seg52_res dst7_seg53 5.100000e-11
c_lev3_src4_dst7_seg52 dst7_seg53 0 4.900000e-15

r_lev3_src4_dst7_seg53 dst7_seg53 dst7_seg53_res 2.550000e-01
l_lev3_src4_dst7_seg53 dst7_seg53_res dst7_seg54 5.100000e-11
c_lev3_src4_dst7_seg53 dst7_seg54 0 4.900000e-15

r_lev3_src4_dst7_seg54 dst7_seg54 dst7_seg54_res 2.550000e-01
l_lev3_src4_dst7_seg54 dst7_seg54_res dst7_seg55 5.100000e-11
c_lev3_src4_dst7_seg54 dst7_seg55 0 4.900000e-15

r_lev3_src4_dst7_seg55 dst7_seg55 dst7_seg55_res 2.550000e-01
l_lev3_src4_dst7_seg55 dst7_seg55_res dst7_seg56 5.100000e-11
c_lev3_src4_dst7_seg55 dst7_seg56 0 4.900000e-15

r_lev3_src4_dst7_seg56 dst7_seg56 dst7_seg56_res 2.550000e-01
l_lev3_src4_dst7_seg56 dst7_seg56_res dst7_seg57 5.100000e-11
c_lev3_src4_dst7_seg56 dst7_seg57 0 4.900000e-15

r_lev3_src4_dst7_seg57 dst7_seg57 dst7_seg57_res 2.550000e-01
l_lev3_src4_dst7_seg57 dst7_seg57_res dst7_seg58 5.100000e-11
c_lev3_src4_dst7_seg57 dst7_seg58 0 4.900000e-15

r_lev3_src4_dst7_seg58 dst7_seg58 dst7_seg58_res 2.550000e-01
l_lev3_src4_dst7_seg58 dst7_seg58_res dst7_seg59 5.100000e-11
c_lev3_src4_dst7_seg58 dst7_seg59 0 4.900000e-15

r_lev3_src4_dst7_seg59 dst7_seg59 dst7_seg59_res 2.550000e-01
l_lev3_src4_dst7_seg59 dst7_seg59_res dst7_seg60 5.100000e-11
c_lev3_src4_dst7_seg59 dst7_seg60 0 4.900000e-15

r_lev3_src4_dst7_seg60 dst7_seg60 dst7_seg60_res 2.550000e-01
l_lev3_src4_dst7_seg60 dst7_seg60_res pt7 5.100000e-11
c_lev3_src4_dst7_seg60 pt7 0 4.900000e-15

r_lev3_src4_dst8_seg1 pt4 dst8_seg1_res 2.550000e-01
l_lev3_src4_dst8_seg1 dst8_seg1_res dst8_seg2 5.100000e-11
c_lev3_src4_dst8_seg1 dst8_seg2 0 4.900000e-15

r_lev3_src4_dst8_seg2 dst8_seg2 dst8_seg2_res 2.550000e-01
l_lev3_src4_dst8_seg2 dst8_seg2_res dst8_seg3 5.100000e-11
c_lev3_src4_dst8_seg2 dst8_seg3 0 4.900000e-15

r_lev3_src4_dst8_seg3 dst8_seg3 dst8_seg3_res 2.550000e-01
l_lev3_src4_dst8_seg3 dst8_seg3_res dst8_seg4 5.100000e-11
c_lev3_src4_dst8_seg3 dst8_seg4 0 4.900000e-15

r_lev3_src4_dst8_seg4 dst8_seg4 dst8_seg4_res 2.550000e-01
l_lev3_src4_dst8_seg4 dst8_seg4_res dst8_seg5 5.100000e-11
c_lev3_src4_dst8_seg4 dst8_seg5 0 4.900000e-15

r_lev3_src4_dst8_seg5 dst8_seg5 dst8_seg5_res 2.550000e-01
l_lev3_src4_dst8_seg5 dst8_seg5_res dst8_seg6 5.100000e-11
c_lev3_src4_dst8_seg5 dst8_seg6 0 4.900000e-15

r_lev3_src4_dst8_seg6 dst8_seg6 dst8_seg6_res 2.550000e-01
l_lev3_src4_dst8_seg6 dst8_seg6_res dst8_seg7 5.100000e-11
c_lev3_src4_dst8_seg6 dst8_seg7 0 4.900000e-15

r_lev3_src4_dst8_seg7 dst8_seg7 dst8_seg7_res 2.550000e-01
l_lev3_src4_dst8_seg7 dst8_seg7_res dst8_seg8 5.100000e-11
c_lev3_src4_dst8_seg7 dst8_seg8 0 4.900000e-15

r_lev3_src4_dst8_seg8 dst8_seg8 dst8_seg8_res 2.550000e-01
l_lev3_src4_dst8_seg8 dst8_seg8_res dst8_seg9 5.100000e-11
c_lev3_src4_dst8_seg8 dst8_seg9 0 4.900000e-15

r_lev3_src4_dst8_seg9 dst8_seg9 dst8_seg9_res 2.550000e-01
l_lev3_src4_dst8_seg9 dst8_seg9_res dst8_seg10 5.100000e-11
c_lev3_src4_dst8_seg9 dst8_seg10 0 4.900000e-15

r_lev3_src4_dst8_seg10 dst8_seg10 dst8_seg10_res 2.550000e-01
l_lev3_src4_dst8_seg10 dst8_seg10_res dst8_seg11 5.100000e-11
c_lev3_src4_dst8_seg10 dst8_seg11 0 4.900000e-15

r_lev3_src4_dst8_seg11 dst8_seg11 dst8_seg11_res 2.550000e-01
l_lev3_src4_dst8_seg11 dst8_seg11_res dst8_seg12 5.100000e-11
c_lev3_src4_dst8_seg11 dst8_seg12 0 4.900000e-15

r_lev3_src4_dst8_seg12 dst8_seg12 dst8_seg12_res 2.550000e-01
l_lev3_src4_dst8_seg12 dst8_seg12_res dst8_seg13 5.100000e-11
c_lev3_src4_dst8_seg12 dst8_seg13 0 4.900000e-15

r_lev3_src4_dst8_seg13 dst8_seg13 dst8_seg13_res 2.550000e-01
l_lev3_src4_dst8_seg13 dst8_seg13_res dst8_seg14 5.100000e-11
c_lev3_src4_dst8_seg13 dst8_seg14 0 4.900000e-15

r_lev3_src4_dst8_seg14 dst8_seg14 dst8_seg14_res 2.550000e-01
l_lev3_src4_dst8_seg14 dst8_seg14_res dst8_seg15 5.100000e-11
c_lev3_src4_dst8_seg14 dst8_seg15 0 4.900000e-15

r_lev3_src4_dst8_seg15 dst8_seg15 dst8_seg15_res 2.550000e-01
l_lev3_src4_dst8_seg15 dst8_seg15_res dst8_seg16 5.100000e-11
c_lev3_src4_dst8_seg15 dst8_seg16 0 4.900000e-15

r_lev3_src4_dst8_seg16 dst8_seg16 dst8_seg16_res 2.550000e-01
l_lev3_src4_dst8_seg16 dst8_seg16_res dst8_seg17 5.100000e-11
c_lev3_src4_dst8_seg16 dst8_seg17 0 4.900000e-15

r_lev3_src4_dst8_seg17 dst8_seg17 dst8_seg17_res 2.550000e-01
l_lev3_src4_dst8_seg17 dst8_seg17_res dst8_seg18 5.100000e-11
c_lev3_src4_dst8_seg17 dst8_seg18 0 4.900000e-15

r_lev3_src4_dst8_seg18 dst8_seg18 dst8_seg18_res 2.550000e-01
l_lev3_src4_dst8_seg18 dst8_seg18_res dst8_seg19 5.100000e-11
c_lev3_src4_dst8_seg18 dst8_seg19 0 4.900000e-15

r_lev3_src4_dst8_seg19 dst8_seg19 dst8_seg19_res 2.550000e-01
l_lev3_src4_dst8_seg19 dst8_seg19_res dst8_seg20 5.100000e-11
c_lev3_src4_dst8_seg19 dst8_seg20 0 4.900000e-15

r_lev3_src4_dst8_seg20 dst8_seg20 dst8_seg20_res 2.550000e-01
l_lev3_src4_dst8_seg20 dst8_seg20_res dst8_seg21 5.100000e-11
c_lev3_src4_dst8_seg20 dst8_seg21 0 4.900000e-15

r_lev3_src4_dst8_seg21 dst8_seg21 dst8_seg21_res 2.550000e-01
l_lev3_src4_dst8_seg21 dst8_seg21_res dst8_seg22 5.100000e-11
c_lev3_src4_dst8_seg21 dst8_seg22 0 4.900000e-15

r_lev3_src4_dst8_seg22 dst8_seg22 dst8_seg22_res 2.550000e-01
l_lev3_src4_dst8_seg22 dst8_seg22_res dst8_seg23 5.100000e-11
c_lev3_src4_dst8_seg22 dst8_seg23 0 4.900000e-15

r_lev3_src4_dst8_seg23 dst8_seg23 dst8_seg23_res 2.550000e-01
l_lev3_src4_dst8_seg23 dst8_seg23_res dst8_seg24 5.100000e-11
c_lev3_src4_dst8_seg23 dst8_seg24 0 4.900000e-15

r_lev3_src4_dst8_seg24 dst8_seg24 dst8_seg24_res 2.550000e-01
l_lev3_src4_dst8_seg24 dst8_seg24_res dst8_seg25 5.100000e-11
c_lev3_src4_dst8_seg24 dst8_seg25 0 4.900000e-15

r_lev3_src4_dst8_seg25 dst8_seg25 dst8_seg25_res 2.550000e-01
l_lev3_src4_dst8_seg25 dst8_seg25_res dst8_seg26 5.100000e-11
c_lev3_src4_dst8_seg25 dst8_seg26 0 4.900000e-15

r_lev3_src4_dst8_seg26 dst8_seg26 dst8_seg26_res 2.550000e-01
l_lev3_src4_dst8_seg26 dst8_seg26_res dst8_seg27 5.100000e-11
c_lev3_src4_dst8_seg26 dst8_seg27 0 4.900000e-15

r_lev3_src4_dst8_seg27 dst8_seg27 dst8_seg27_res 2.550000e-01
l_lev3_src4_dst8_seg27 dst8_seg27_res dst8_seg28 5.100000e-11
c_lev3_src4_dst8_seg27 dst8_seg28 0 4.900000e-15

r_lev3_src4_dst8_seg28 dst8_seg28 dst8_seg28_res 2.550000e-01
l_lev3_src4_dst8_seg28 dst8_seg28_res dst8_seg29 5.100000e-11
c_lev3_src4_dst8_seg28 dst8_seg29 0 4.900000e-15

r_lev3_src4_dst8_seg29 dst8_seg29 dst8_seg29_res 2.550000e-01
l_lev3_src4_dst8_seg29 dst8_seg29_res dst8_seg30 5.100000e-11
c_lev3_src4_dst8_seg29 dst8_seg30 0 4.900000e-15

r_lev3_src4_dst8_seg30 dst8_seg30 dst8_seg30_res 2.550000e-01
l_lev3_src4_dst8_seg30 dst8_seg30_res dst8_seg31 5.100000e-11
c_lev3_src4_dst8_seg30 dst8_seg31 0 4.900000e-15

r_lev3_src4_dst8_seg31 dst8_seg31 dst8_seg31_res 2.550000e-01
l_lev3_src4_dst8_seg31 dst8_seg31_res dst8_seg32 5.100000e-11
c_lev3_src4_dst8_seg31 dst8_seg32 0 4.900000e-15

r_lev3_src4_dst8_seg32 dst8_seg32 dst8_seg32_res 2.550000e-01
l_lev3_src4_dst8_seg32 dst8_seg32_res dst8_seg33 5.100000e-11
c_lev3_src4_dst8_seg32 dst8_seg33 0 4.900000e-15

r_lev3_src4_dst8_seg33 dst8_seg33 dst8_seg33_res 2.550000e-01
l_lev3_src4_dst8_seg33 dst8_seg33_res dst8_seg34 5.100000e-11
c_lev3_src4_dst8_seg33 dst8_seg34 0 4.900000e-15

r_lev3_src4_dst8_seg34 dst8_seg34 dst8_seg34_res 2.550000e-01
l_lev3_src4_dst8_seg34 dst8_seg34_res dst8_seg35 5.100000e-11
c_lev3_src4_dst8_seg34 dst8_seg35 0 4.900000e-15

r_lev3_src4_dst8_seg35 dst8_seg35 dst8_seg35_res 2.550000e-01
l_lev3_src4_dst8_seg35 dst8_seg35_res dst8_seg36 5.100000e-11
c_lev3_src4_dst8_seg35 dst8_seg36 0 4.900000e-15

r_lev3_src4_dst8_seg36 dst8_seg36 dst8_seg36_res 2.550000e-01
l_lev3_src4_dst8_seg36 dst8_seg36_res dst8_seg37 5.100000e-11
c_lev3_src4_dst8_seg36 dst8_seg37 0 4.900000e-15

r_lev3_src4_dst8_seg37 dst8_seg37 dst8_seg37_res 2.550000e-01
l_lev3_src4_dst8_seg37 dst8_seg37_res dst8_seg38 5.100000e-11
c_lev3_src4_dst8_seg37 dst8_seg38 0 4.900000e-15

r_lev3_src4_dst8_seg38 dst8_seg38 dst8_seg38_res 2.550000e-01
l_lev3_src4_dst8_seg38 dst8_seg38_res dst8_seg39 5.100000e-11
c_lev3_src4_dst8_seg38 dst8_seg39 0 4.900000e-15

r_lev3_src4_dst8_seg39 dst8_seg39 dst8_seg39_res 2.550000e-01
l_lev3_src4_dst8_seg39 dst8_seg39_res dst8_seg40 5.100000e-11
c_lev3_src4_dst8_seg39 dst8_seg40 0 4.900000e-15

r_lev3_src4_dst8_seg40 dst8_seg40 dst8_seg40_res 2.550000e-01
l_lev3_src4_dst8_seg40 dst8_seg40_res dst8_seg41 5.100000e-11
c_lev3_src4_dst8_seg40 dst8_seg41 0 4.900000e-15

r_lev3_src4_dst8_seg41 dst8_seg41 dst8_seg41_res 2.550000e-01
l_lev3_src4_dst8_seg41 dst8_seg41_res dst8_seg42 5.100000e-11
c_lev3_src4_dst8_seg41 dst8_seg42 0 4.900000e-15

r_lev3_src4_dst8_seg42 dst8_seg42 dst8_seg42_res 2.550000e-01
l_lev3_src4_dst8_seg42 dst8_seg42_res dst8_seg43 5.100000e-11
c_lev3_src4_dst8_seg42 dst8_seg43 0 4.900000e-15

r_lev3_src4_dst8_seg43 dst8_seg43 dst8_seg43_res 2.550000e-01
l_lev3_src4_dst8_seg43 dst8_seg43_res dst8_seg44 5.100000e-11
c_lev3_src4_dst8_seg43 dst8_seg44 0 4.900000e-15

r_lev3_src4_dst8_seg44 dst8_seg44 dst8_seg44_res 2.550000e-01
l_lev3_src4_dst8_seg44 dst8_seg44_res dst8_seg45 5.100000e-11
c_lev3_src4_dst8_seg44 dst8_seg45 0 4.900000e-15

r_lev3_src4_dst8_seg45 dst8_seg45 dst8_seg45_res 2.550000e-01
l_lev3_src4_dst8_seg45 dst8_seg45_res dst8_seg46 5.100000e-11
c_lev3_src4_dst8_seg45 dst8_seg46 0 4.900000e-15

r_lev3_src4_dst8_seg46 dst8_seg46 dst8_seg46_res 2.550000e-01
l_lev3_src4_dst8_seg46 dst8_seg46_res dst8_seg47 5.100000e-11
c_lev3_src4_dst8_seg46 dst8_seg47 0 4.900000e-15

r_lev3_src4_dst8_seg47 dst8_seg47 dst8_seg47_res 2.550000e-01
l_lev3_src4_dst8_seg47 dst8_seg47_res dst8_seg48 5.100000e-11
c_lev3_src4_dst8_seg47 dst8_seg48 0 4.900000e-15

r_lev3_src4_dst8_seg48 dst8_seg48 dst8_seg48_res 2.550000e-01
l_lev3_src4_dst8_seg48 dst8_seg48_res dst8_seg49 5.100000e-11
c_lev3_src4_dst8_seg48 dst8_seg49 0 4.900000e-15

r_lev3_src4_dst8_seg49 dst8_seg49 dst8_seg49_res 2.550000e-01
l_lev3_src4_dst8_seg49 dst8_seg49_res dst8_seg50 5.100000e-11
c_lev3_src4_dst8_seg49 dst8_seg50 0 4.900000e-15

r_lev3_src4_dst8_seg50 dst8_seg50 dst8_seg50_res 2.550000e-01
l_lev3_src4_dst8_seg50 dst8_seg50_res dst8_seg51 5.100000e-11
c_lev3_src4_dst8_seg50 dst8_seg51 0 4.900000e-15

r_lev3_src4_dst8_seg51 dst8_seg51 dst8_seg51_res 2.550000e-01
l_lev3_src4_dst8_seg51 dst8_seg51_res dst8_seg52 5.100000e-11
c_lev3_src4_dst8_seg51 dst8_seg52 0 4.900000e-15

r_lev3_src4_dst8_seg52 dst8_seg52 dst8_seg52_res 2.550000e-01
l_lev3_src4_dst8_seg52 dst8_seg52_res dst8_seg53 5.100000e-11
c_lev3_src4_dst8_seg52 dst8_seg53 0 4.900000e-15

r_lev3_src4_dst8_seg53 dst8_seg53 dst8_seg53_res 2.550000e-01
l_lev3_src4_dst8_seg53 dst8_seg53_res dst8_seg54 5.100000e-11
c_lev3_src4_dst8_seg53 dst8_seg54 0 4.900000e-15

r_lev3_src4_dst8_seg54 dst8_seg54 dst8_seg54_res 2.550000e-01
l_lev3_src4_dst8_seg54 dst8_seg54_res dst8_seg55 5.100000e-11
c_lev3_src4_dst8_seg54 dst8_seg55 0 4.900000e-15

r_lev3_src4_dst8_seg55 dst8_seg55 dst8_seg55_res 2.550000e-01
l_lev3_src4_dst8_seg55 dst8_seg55_res dst8_seg56 5.100000e-11
c_lev3_src4_dst8_seg55 dst8_seg56 0 4.900000e-15

r_lev3_src4_dst8_seg56 dst8_seg56 dst8_seg56_res 2.550000e-01
l_lev3_src4_dst8_seg56 dst8_seg56_res dst8_seg57 5.100000e-11
c_lev3_src4_dst8_seg56 dst8_seg57 0 4.900000e-15

r_lev3_src4_dst8_seg57 dst8_seg57 dst8_seg57_res 2.550000e-01
l_lev3_src4_dst8_seg57 dst8_seg57_res dst8_seg58 5.100000e-11
c_lev3_src4_dst8_seg57 dst8_seg58 0 4.900000e-15

r_lev3_src4_dst8_seg58 dst8_seg58 dst8_seg58_res 2.550000e-01
l_lev3_src4_dst8_seg58 dst8_seg58_res dst8_seg59 5.100000e-11
c_lev3_src4_dst8_seg58 dst8_seg59 0 4.900000e-15

r_lev3_src4_dst8_seg59 dst8_seg59 dst8_seg59_res 2.550000e-01
l_lev3_src4_dst8_seg59 dst8_seg59_res dst8_seg60 5.100000e-11
c_lev3_src4_dst8_seg59 dst8_seg60 0 4.900000e-15

r_lev3_src4_dst8_seg60 dst8_seg60 dst8_seg60_res 2.550000e-01
l_lev3_src4_dst8_seg60 dst8_seg60_res pt8 5.100000e-11
c_lev3_src4_dst8_seg60 pt8 0 4.900000e-15

r_lev4_src5_dst9_seg1 pt5 dst9_seg1_res 2.550000e-01
l_lev4_src5_dst9_seg1 dst9_seg1_res dst9_seg2 5.100000e-11
c_lev4_src5_dst9_seg1 dst9_seg2 0 4.900000e-15

r_lev4_src5_dst9_seg2 dst9_seg2 dst9_seg2_res 2.550000e-01
l_lev4_src5_dst9_seg2 dst9_seg2_res dst9_seg3 5.100000e-11
c_lev4_src5_dst9_seg2 dst9_seg3 0 4.900000e-15

r_lev4_src5_dst9_seg3 dst9_seg3 dst9_seg3_res 2.550000e-01
l_lev4_src5_dst9_seg3 dst9_seg3_res dst9_seg4 5.100000e-11
c_lev4_src5_dst9_seg3 dst9_seg4 0 4.900000e-15

r_lev4_src5_dst9_seg4 dst9_seg4 dst9_seg4_res 2.550000e-01
l_lev4_src5_dst9_seg4 dst9_seg4_res dst9_seg5 5.100000e-11
c_lev4_src5_dst9_seg4 dst9_seg5 0 4.900000e-15

r_lev4_src5_dst9_seg5 dst9_seg5 dst9_seg5_res 2.550000e-01
l_lev4_src5_dst9_seg5 dst9_seg5_res dst9_seg6 5.100000e-11
c_lev4_src5_dst9_seg5 dst9_seg6 0 4.900000e-15

r_lev4_src5_dst9_seg6 dst9_seg6 dst9_seg6_res 2.550000e-01
l_lev4_src5_dst9_seg6 dst9_seg6_res dst9_seg7 5.100000e-11
c_lev4_src5_dst9_seg6 dst9_seg7 0 4.900000e-15

r_lev4_src5_dst9_seg7 dst9_seg7 dst9_seg7_res 2.550000e-01
l_lev4_src5_dst9_seg7 dst9_seg7_res dst9_seg8 5.100000e-11
c_lev4_src5_dst9_seg7 dst9_seg8 0 4.900000e-15

r_lev4_src5_dst9_seg8 dst9_seg8 dst9_seg8_res 2.550000e-01
l_lev4_src5_dst9_seg8 dst9_seg8_res dst9_seg9 5.100000e-11
c_lev4_src5_dst9_seg8 dst9_seg9 0 4.900000e-15

r_lev4_src5_dst9_seg9 dst9_seg9 dst9_seg9_res 2.550000e-01
l_lev4_src5_dst9_seg9 dst9_seg9_res dst9_seg10 5.100000e-11
c_lev4_src5_dst9_seg9 dst9_seg10 0 4.900000e-15

r_lev4_src5_dst9_seg10 dst9_seg10 dst9_seg10_res 2.550000e-01
l_lev4_src5_dst9_seg10 dst9_seg10_res dst9_seg11 5.100000e-11
c_lev4_src5_dst9_seg10 dst9_seg11 0 4.900000e-15

r_lev4_src5_dst9_seg11 dst9_seg11 dst9_seg11_res 2.550000e-01
l_lev4_src5_dst9_seg11 dst9_seg11_res dst9_seg12 5.100000e-11
c_lev4_src5_dst9_seg11 dst9_seg12 0 4.900000e-15

r_lev4_src5_dst9_seg12 dst9_seg12 dst9_seg12_res 2.550000e-01
l_lev4_src5_dst9_seg12 dst9_seg12_res dst9_seg13 5.100000e-11
c_lev4_src5_dst9_seg12 dst9_seg13 0 4.900000e-15

r_lev4_src5_dst9_seg13 dst9_seg13 dst9_seg13_res 2.550000e-01
l_lev4_src5_dst9_seg13 dst9_seg13_res dst9_seg14 5.100000e-11
c_lev4_src5_dst9_seg13 dst9_seg14 0 4.900000e-15

r_lev4_src5_dst9_seg14 dst9_seg14 dst9_seg14_res 2.550000e-01
l_lev4_src5_dst9_seg14 dst9_seg14_res dst9_seg15 5.100000e-11
c_lev4_src5_dst9_seg14 dst9_seg15 0 4.900000e-15

r_lev4_src5_dst9_seg15 dst9_seg15 dst9_seg15_res 2.550000e-01
l_lev4_src5_dst9_seg15 dst9_seg15_res dst9_seg16 5.100000e-11
c_lev4_src5_dst9_seg15 dst9_seg16 0 4.900000e-15

r_lev4_src5_dst9_seg16 dst9_seg16 dst9_seg16_res 2.550000e-01
l_lev4_src5_dst9_seg16 dst9_seg16_res dst9_seg17 5.100000e-11
c_lev4_src5_dst9_seg16 dst9_seg17 0 4.900000e-15

r_lev4_src5_dst9_seg17 dst9_seg17 dst9_seg17_res 2.550000e-01
l_lev4_src5_dst9_seg17 dst9_seg17_res dst9_seg18 5.100000e-11
c_lev4_src5_dst9_seg17 dst9_seg18 0 4.900000e-15

r_lev4_src5_dst9_seg18 dst9_seg18 dst9_seg18_res 2.550000e-01
l_lev4_src5_dst9_seg18 dst9_seg18_res dst9_seg19 5.100000e-11
c_lev4_src5_dst9_seg18 dst9_seg19 0 4.900000e-15

r_lev4_src5_dst9_seg19 dst9_seg19 dst9_seg19_res 2.550000e-01
l_lev4_src5_dst9_seg19 dst9_seg19_res dst9_seg20 5.100000e-11
c_lev4_src5_dst9_seg19 dst9_seg20 0 4.900000e-15

r_lev4_src5_dst9_seg20 dst9_seg20 dst9_seg20_res 2.550000e-01
l_lev4_src5_dst9_seg20 dst9_seg20_res dst9_seg21 5.100000e-11
c_lev4_src5_dst9_seg20 dst9_seg21 0 4.900000e-15

r_lev4_src5_dst9_seg21 dst9_seg21 dst9_seg21_res 2.550000e-01
l_lev4_src5_dst9_seg21 dst9_seg21_res dst9_seg22 5.100000e-11
c_lev4_src5_dst9_seg21 dst9_seg22 0 4.900000e-15

r_lev4_src5_dst9_seg22 dst9_seg22 dst9_seg22_res 2.550000e-01
l_lev4_src5_dst9_seg22 dst9_seg22_res dst9_seg23 5.100000e-11
c_lev4_src5_dst9_seg22 dst9_seg23 0 4.900000e-15

r_lev4_src5_dst9_seg23 dst9_seg23 dst9_seg23_res 2.550000e-01
l_lev4_src5_dst9_seg23 dst9_seg23_res dst9_seg24 5.100000e-11
c_lev4_src5_dst9_seg23 dst9_seg24 0 4.900000e-15

r_lev4_src5_dst9_seg24 dst9_seg24 dst9_seg24_res 2.550000e-01
l_lev4_src5_dst9_seg24 dst9_seg24_res dst9_seg25 5.100000e-11
c_lev4_src5_dst9_seg24 dst9_seg25 0 4.900000e-15

r_lev4_src5_dst9_seg25 dst9_seg25 dst9_seg25_res 2.550000e-01
l_lev4_src5_dst9_seg25 dst9_seg25_res dst9_seg26 5.100000e-11
c_lev4_src5_dst9_seg25 dst9_seg26 0 4.900000e-15

r_lev4_src5_dst9_seg26 dst9_seg26 dst9_seg26_res 2.550000e-01
l_lev4_src5_dst9_seg26 dst9_seg26_res dst9_seg27 5.100000e-11
c_lev4_src5_dst9_seg26 dst9_seg27 0 4.900000e-15

r_lev4_src5_dst9_seg27 dst9_seg27 dst9_seg27_res 2.550000e-01
l_lev4_src5_dst9_seg27 dst9_seg27_res dst9_seg28 5.100000e-11
c_lev4_src5_dst9_seg27 dst9_seg28 0 4.900000e-15

r_lev4_src5_dst9_seg28 dst9_seg28 dst9_seg28_res 2.550000e-01
l_lev4_src5_dst9_seg28 dst9_seg28_res dst9_seg29 5.100000e-11
c_lev4_src5_dst9_seg28 dst9_seg29 0 4.900000e-15

r_lev4_src5_dst9_seg29 dst9_seg29 dst9_seg29_res 2.550000e-01
l_lev4_src5_dst9_seg29 dst9_seg29_res dst9_seg30 5.100000e-11
c_lev4_src5_dst9_seg29 dst9_seg30 0 4.900000e-15

r_lev4_src5_dst9_seg30 dst9_seg30 dst9_seg30_res 2.550000e-01
l_lev4_src5_dst9_seg30 dst9_seg30_res dst9_seg31 5.100000e-11
c_lev4_src5_dst9_seg30 dst9_seg31 0 4.900000e-15

r_lev4_src5_dst9_seg31 dst9_seg31 dst9_seg31_res 2.550000e-01
l_lev4_src5_dst9_seg31 dst9_seg31_res dst9_seg32 5.100000e-11
c_lev4_src5_dst9_seg31 dst9_seg32 0 4.900000e-15

r_lev4_src5_dst9_seg32 dst9_seg32 dst9_seg32_res 2.550000e-01
l_lev4_src5_dst9_seg32 dst9_seg32_res dst9_seg33 5.100000e-11
c_lev4_src5_dst9_seg32 dst9_seg33 0 4.900000e-15

r_lev4_src5_dst9_seg33 dst9_seg33 dst9_seg33_res 2.550000e-01
l_lev4_src5_dst9_seg33 dst9_seg33_res dst9_seg34 5.100000e-11
c_lev4_src5_dst9_seg33 dst9_seg34 0 4.900000e-15

r_lev4_src5_dst9_seg34 dst9_seg34 dst9_seg34_res 2.550000e-01
l_lev4_src5_dst9_seg34 dst9_seg34_res dst9_seg35 5.100000e-11
c_lev4_src5_dst9_seg34 dst9_seg35 0 4.900000e-15

r_lev4_src5_dst9_seg35 dst9_seg35 dst9_seg35_res 2.550000e-01
l_lev4_src5_dst9_seg35 dst9_seg35_res dst9_seg36 5.100000e-11
c_lev4_src5_dst9_seg35 dst9_seg36 0 4.900000e-15

r_lev4_src5_dst9_seg36 dst9_seg36 dst9_seg36_res 2.550000e-01
l_lev4_src5_dst9_seg36 dst9_seg36_res dst9_seg37 5.100000e-11
c_lev4_src5_dst9_seg36 dst9_seg37 0 4.900000e-15

r_lev4_src5_dst9_seg37 dst9_seg37 dst9_seg37_res 2.550000e-01
l_lev4_src5_dst9_seg37 dst9_seg37_res dst9_seg38 5.100000e-11
c_lev4_src5_dst9_seg37 dst9_seg38 0 4.900000e-15

r_lev4_src5_dst9_seg38 dst9_seg38 dst9_seg38_res 2.550000e-01
l_lev4_src5_dst9_seg38 dst9_seg38_res dst9_seg39 5.100000e-11
c_lev4_src5_dst9_seg38 dst9_seg39 0 4.900000e-15

r_lev4_src5_dst9_seg39 dst9_seg39 dst9_seg39_res 2.550000e-01
l_lev4_src5_dst9_seg39 dst9_seg39_res dst9_seg40 5.100000e-11
c_lev4_src5_dst9_seg39 dst9_seg40 0 4.900000e-15

r_lev4_src5_dst9_seg40 dst9_seg40 dst9_seg40_res 2.550000e-01
l_lev4_src5_dst9_seg40 dst9_seg40_res pt9 5.100000e-11
c_lev4_src5_dst9_seg40 pt9 0 4.900000e-15

r_lev4_dst9_load pt9 0 5.000000e+03
c_lev4_dst9_load pt9 0 5.000000e-15

r_lev4_src5_dst10_seg1 pt5 dst10_seg1_res 2.550000e-01
l_lev4_src5_dst10_seg1 dst10_seg1_res dst10_seg2 5.100000e-11
c_lev4_src5_dst10_seg1 dst10_seg2 0 4.900000e-15

r_lev4_src5_dst10_seg2 dst10_seg2 dst10_seg2_res 2.550000e-01
l_lev4_src5_dst10_seg2 dst10_seg2_res dst10_seg3 5.100000e-11
c_lev4_src5_dst10_seg2 dst10_seg3 0 4.900000e-15

r_lev4_src5_dst10_seg3 dst10_seg3 dst10_seg3_res 2.550000e-01
l_lev4_src5_dst10_seg3 dst10_seg3_res dst10_seg4 5.100000e-11
c_lev4_src5_dst10_seg3 dst10_seg4 0 4.900000e-15

r_lev4_src5_dst10_seg4 dst10_seg4 dst10_seg4_res 2.550000e-01
l_lev4_src5_dst10_seg4 dst10_seg4_res dst10_seg5 5.100000e-11
c_lev4_src5_dst10_seg4 dst10_seg5 0 4.900000e-15

r_lev4_src5_dst10_seg5 dst10_seg5 dst10_seg5_res 2.550000e-01
l_lev4_src5_dst10_seg5 dst10_seg5_res dst10_seg6 5.100000e-11
c_lev4_src5_dst10_seg5 dst10_seg6 0 4.900000e-15

r_lev4_src5_dst10_seg6 dst10_seg6 dst10_seg6_res 2.550000e-01
l_lev4_src5_dst10_seg6 dst10_seg6_res dst10_seg7 5.100000e-11
c_lev4_src5_dst10_seg6 dst10_seg7 0 4.900000e-15

r_lev4_src5_dst10_seg7 dst10_seg7 dst10_seg7_res 2.550000e-01
l_lev4_src5_dst10_seg7 dst10_seg7_res dst10_seg8 5.100000e-11
c_lev4_src5_dst10_seg7 dst10_seg8 0 4.900000e-15

r_lev4_src5_dst10_seg8 dst10_seg8 dst10_seg8_res 2.550000e-01
l_lev4_src5_dst10_seg8 dst10_seg8_res dst10_seg9 5.100000e-11
c_lev4_src5_dst10_seg8 dst10_seg9 0 4.900000e-15

r_lev4_src5_dst10_seg9 dst10_seg9 dst10_seg9_res 2.550000e-01
l_lev4_src5_dst10_seg9 dst10_seg9_res dst10_seg10 5.100000e-11
c_lev4_src5_dst10_seg9 dst10_seg10 0 4.900000e-15

r_lev4_src5_dst10_seg10 dst10_seg10 dst10_seg10_res 2.550000e-01
l_lev4_src5_dst10_seg10 dst10_seg10_res dst10_seg11 5.100000e-11
c_lev4_src5_dst10_seg10 dst10_seg11 0 4.900000e-15

r_lev4_src5_dst10_seg11 dst10_seg11 dst10_seg11_res 2.550000e-01
l_lev4_src5_dst10_seg11 dst10_seg11_res dst10_seg12 5.100000e-11
c_lev4_src5_dst10_seg11 dst10_seg12 0 4.900000e-15

r_lev4_src5_dst10_seg12 dst10_seg12 dst10_seg12_res 2.550000e-01
l_lev4_src5_dst10_seg12 dst10_seg12_res dst10_seg13 5.100000e-11
c_lev4_src5_dst10_seg12 dst10_seg13 0 4.900000e-15

r_lev4_src5_dst10_seg13 dst10_seg13 dst10_seg13_res 2.550000e-01
l_lev4_src5_dst10_seg13 dst10_seg13_res dst10_seg14 5.100000e-11
c_lev4_src5_dst10_seg13 dst10_seg14 0 4.900000e-15

r_lev4_src5_dst10_seg14 dst10_seg14 dst10_seg14_res 2.550000e-01
l_lev4_src5_dst10_seg14 dst10_seg14_res dst10_seg15 5.100000e-11
c_lev4_src5_dst10_seg14 dst10_seg15 0 4.900000e-15

r_lev4_src5_dst10_seg15 dst10_seg15 dst10_seg15_res 2.550000e-01
l_lev4_src5_dst10_seg15 dst10_seg15_res dst10_seg16 5.100000e-11
c_lev4_src5_dst10_seg15 dst10_seg16 0 4.900000e-15

r_lev4_src5_dst10_seg16 dst10_seg16 dst10_seg16_res 2.550000e-01
l_lev4_src5_dst10_seg16 dst10_seg16_res dst10_seg17 5.100000e-11
c_lev4_src5_dst10_seg16 dst10_seg17 0 4.900000e-15

r_lev4_src5_dst10_seg17 dst10_seg17 dst10_seg17_res 2.550000e-01
l_lev4_src5_dst10_seg17 dst10_seg17_res dst10_seg18 5.100000e-11
c_lev4_src5_dst10_seg17 dst10_seg18 0 4.900000e-15

r_lev4_src5_dst10_seg18 dst10_seg18 dst10_seg18_res 2.550000e-01
l_lev4_src5_dst10_seg18 dst10_seg18_res dst10_seg19 5.100000e-11
c_lev4_src5_dst10_seg18 dst10_seg19 0 4.900000e-15

r_lev4_src5_dst10_seg19 dst10_seg19 dst10_seg19_res 2.550000e-01
l_lev4_src5_dst10_seg19 dst10_seg19_res dst10_seg20 5.100000e-11
c_lev4_src5_dst10_seg19 dst10_seg20 0 4.900000e-15

r_lev4_src5_dst10_seg20 dst10_seg20 dst10_seg20_res 2.550000e-01
l_lev4_src5_dst10_seg20 dst10_seg20_res dst10_seg21 5.100000e-11
c_lev4_src5_dst10_seg20 dst10_seg21 0 4.900000e-15

r_lev4_src5_dst10_seg21 dst10_seg21 dst10_seg21_res 2.550000e-01
l_lev4_src5_dst10_seg21 dst10_seg21_res dst10_seg22 5.100000e-11
c_lev4_src5_dst10_seg21 dst10_seg22 0 4.900000e-15

r_lev4_src5_dst10_seg22 dst10_seg22 dst10_seg22_res 2.550000e-01
l_lev4_src5_dst10_seg22 dst10_seg22_res dst10_seg23 5.100000e-11
c_lev4_src5_dst10_seg22 dst10_seg23 0 4.900000e-15

r_lev4_src5_dst10_seg23 dst10_seg23 dst10_seg23_res 2.550000e-01
l_lev4_src5_dst10_seg23 dst10_seg23_res dst10_seg24 5.100000e-11
c_lev4_src5_dst10_seg23 dst10_seg24 0 4.900000e-15

r_lev4_src5_dst10_seg24 dst10_seg24 dst10_seg24_res 2.550000e-01
l_lev4_src5_dst10_seg24 dst10_seg24_res dst10_seg25 5.100000e-11
c_lev4_src5_dst10_seg24 dst10_seg25 0 4.900000e-15

r_lev4_src5_dst10_seg25 dst10_seg25 dst10_seg25_res 2.550000e-01
l_lev4_src5_dst10_seg25 dst10_seg25_res dst10_seg26 5.100000e-11
c_lev4_src5_dst10_seg25 dst10_seg26 0 4.900000e-15

r_lev4_src5_dst10_seg26 dst10_seg26 dst10_seg26_res 2.550000e-01
l_lev4_src5_dst10_seg26 dst10_seg26_res dst10_seg27 5.100000e-11
c_lev4_src5_dst10_seg26 dst10_seg27 0 4.900000e-15

r_lev4_src5_dst10_seg27 dst10_seg27 dst10_seg27_res 2.550000e-01
l_lev4_src5_dst10_seg27 dst10_seg27_res dst10_seg28 5.100000e-11
c_lev4_src5_dst10_seg27 dst10_seg28 0 4.900000e-15

r_lev4_src5_dst10_seg28 dst10_seg28 dst10_seg28_res 2.550000e-01
l_lev4_src5_dst10_seg28 dst10_seg28_res dst10_seg29 5.100000e-11
c_lev4_src5_dst10_seg28 dst10_seg29 0 4.900000e-15

r_lev4_src5_dst10_seg29 dst10_seg29 dst10_seg29_res 2.550000e-01
l_lev4_src5_dst10_seg29 dst10_seg29_res dst10_seg30 5.100000e-11
c_lev4_src5_dst10_seg29 dst10_seg30 0 4.900000e-15

r_lev4_src5_dst10_seg30 dst10_seg30 dst10_seg30_res 2.550000e-01
l_lev4_src5_dst10_seg30 dst10_seg30_res dst10_seg31 5.100000e-11
c_lev4_src5_dst10_seg30 dst10_seg31 0 4.900000e-15

r_lev4_src5_dst10_seg31 dst10_seg31 dst10_seg31_res 2.550000e-01
l_lev4_src5_dst10_seg31 dst10_seg31_res dst10_seg32 5.100000e-11
c_lev4_src5_dst10_seg31 dst10_seg32 0 4.900000e-15

r_lev4_src5_dst10_seg32 dst10_seg32 dst10_seg32_res 2.550000e-01
l_lev4_src5_dst10_seg32 dst10_seg32_res dst10_seg33 5.100000e-11
c_lev4_src5_dst10_seg32 dst10_seg33 0 4.900000e-15

r_lev4_src5_dst10_seg33 dst10_seg33 dst10_seg33_res 2.550000e-01
l_lev4_src5_dst10_seg33 dst10_seg33_res dst10_seg34 5.100000e-11
c_lev4_src5_dst10_seg33 dst10_seg34 0 4.900000e-15

r_lev4_src5_dst10_seg34 dst10_seg34 dst10_seg34_res 2.550000e-01
l_lev4_src5_dst10_seg34 dst10_seg34_res dst10_seg35 5.100000e-11
c_lev4_src5_dst10_seg34 dst10_seg35 0 4.900000e-15

r_lev4_src5_dst10_seg35 dst10_seg35 dst10_seg35_res 2.550000e-01
l_lev4_src5_dst10_seg35 dst10_seg35_res dst10_seg36 5.100000e-11
c_lev4_src5_dst10_seg35 dst10_seg36 0 4.900000e-15

r_lev4_src5_dst10_seg36 dst10_seg36 dst10_seg36_res 2.550000e-01
l_lev4_src5_dst10_seg36 dst10_seg36_res dst10_seg37 5.100000e-11
c_lev4_src5_dst10_seg36 dst10_seg37 0 4.900000e-15

r_lev4_src5_dst10_seg37 dst10_seg37 dst10_seg37_res 2.550000e-01
l_lev4_src5_dst10_seg37 dst10_seg37_res dst10_seg38 5.100000e-11
c_lev4_src5_dst10_seg37 dst10_seg38 0 4.900000e-15

r_lev4_src5_dst10_seg38 dst10_seg38 dst10_seg38_res 2.550000e-01
l_lev4_src5_dst10_seg38 dst10_seg38_res dst10_seg39 5.100000e-11
c_lev4_src5_dst10_seg38 dst10_seg39 0 4.900000e-15

r_lev4_src5_dst10_seg39 dst10_seg39 dst10_seg39_res 2.550000e-01
l_lev4_src5_dst10_seg39 dst10_seg39_res dst10_seg40 5.100000e-11
c_lev4_src5_dst10_seg39 dst10_seg40 0 4.900000e-15

r_lev4_src5_dst10_seg40 dst10_seg40 dst10_seg40_res 2.550000e-01
l_lev4_src5_dst10_seg40 dst10_seg40_res pt10 5.100000e-11
c_lev4_src5_dst10_seg40 pt10 0 4.900000e-15

r_lev4_dst10_load pt10 0 5.000000e+03
c_lev4_dst10_load pt10 0 5.000000e-15

r_lev4_src6_dst11_seg1 pt6 dst11_seg1_res 2.550000e-01
l_lev4_src6_dst11_seg1 dst11_seg1_res dst11_seg2 5.100000e-11
c_lev4_src6_dst11_seg1 dst11_seg2 0 4.900000e-15

r_lev4_src6_dst11_seg2 dst11_seg2 dst11_seg2_res 2.550000e-01
l_lev4_src6_dst11_seg2 dst11_seg2_res dst11_seg3 5.100000e-11
c_lev4_src6_dst11_seg2 dst11_seg3 0 4.900000e-15

r_lev4_src6_dst11_seg3 dst11_seg3 dst11_seg3_res 2.550000e-01
l_lev4_src6_dst11_seg3 dst11_seg3_res dst11_seg4 5.100000e-11
c_lev4_src6_dst11_seg3 dst11_seg4 0 4.900000e-15

r_lev4_src6_dst11_seg4 dst11_seg4 dst11_seg4_res 2.550000e-01
l_lev4_src6_dst11_seg4 dst11_seg4_res dst11_seg5 5.100000e-11
c_lev4_src6_dst11_seg4 dst11_seg5 0 4.900000e-15

r_lev4_src6_dst11_seg5 dst11_seg5 dst11_seg5_res 2.550000e-01
l_lev4_src6_dst11_seg5 dst11_seg5_res dst11_seg6 5.100000e-11
c_lev4_src6_dst11_seg5 dst11_seg6 0 4.900000e-15

r_lev4_src6_dst11_seg6 dst11_seg6 dst11_seg6_res 2.550000e-01
l_lev4_src6_dst11_seg6 dst11_seg6_res dst11_seg7 5.100000e-11
c_lev4_src6_dst11_seg6 dst11_seg7 0 4.900000e-15

r_lev4_src6_dst11_seg7 dst11_seg7 dst11_seg7_res 2.550000e-01
l_lev4_src6_dst11_seg7 dst11_seg7_res dst11_seg8 5.100000e-11
c_lev4_src6_dst11_seg7 dst11_seg8 0 4.900000e-15

r_lev4_src6_dst11_seg8 dst11_seg8 dst11_seg8_res 2.550000e-01
l_lev4_src6_dst11_seg8 dst11_seg8_res dst11_seg9 5.100000e-11
c_lev4_src6_dst11_seg8 dst11_seg9 0 4.900000e-15

r_lev4_src6_dst11_seg9 dst11_seg9 dst11_seg9_res 2.550000e-01
l_lev4_src6_dst11_seg9 dst11_seg9_res dst11_seg10 5.100000e-11
c_lev4_src6_dst11_seg9 dst11_seg10 0 4.900000e-15

r_lev4_src6_dst11_seg10 dst11_seg10 dst11_seg10_res 2.550000e-01
l_lev4_src6_dst11_seg10 dst11_seg10_res dst11_seg11 5.100000e-11
c_lev4_src6_dst11_seg10 dst11_seg11 0 4.900000e-15

r_lev4_src6_dst11_seg11 dst11_seg11 dst11_seg11_res 2.550000e-01
l_lev4_src6_dst11_seg11 dst11_seg11_res dst11_seg12 5.100000e-11
c_lev4_src6_dst11_seg11 dst11_seg12 0 4.900000e-15

r_lev4_src6_dst11_seg12 dst11_seg12 dst11_seg12_res 2.550000e-01
l_lev4_src6_dst11_seg12 dst11_seg12_res dst11_seg13 5.100000e-11
c_lev4_src6_dst11_seg12 dst11_seg13 0 4.900000e-15

r_lev4_src6_dst11_seg13 dst11_seg13 dst11_seg13_res 2.550000e-01
l_lev4_src6_dst11_seg13 dst11_seg13_res dst11_seg14 5.100000e-11
c_lev4_src6_dst11_seg13 dst11_seg14 0 4.900000e-15

r_lev4_src6_dst11_seg14 dst11_seg14 dst11_seg14_res 2.550000e-01
l_lev4_src6_dst11_seg14 dst11_seg14_res dst11_seg15 5.100000e-11
c_lev4_src6_dst11_seg14 dst11_seg15 0 4.900000e-15

r_lev4_src6_dst11_seg15 dst11_seg15 dst11_seg15_res 2.550000e-01
l_lev4_src6_dst11_seg15 dst11_seg15_res dst11_seg16 5.100000e-11
c_lev4_src6_dst11_seg15 dst11_seg16 0 4.900000e-15

r_lev4_src6_dst11_seg16 dst11_seg16 dst11_seg16_res 2.550000e-01
l_lev4_src6_dst11_seg16 dst11_seg16_res dst11_seg17 5.100000e-11
c_lev4_src6_dst11_seg16 dst11_seg17 0 4.900000e-15

r_lev4_src6_dst11_seg17 dst11_seg17 dst11_seg17_res 2.550000e-01
l_lev4_src6_dst11_seg17 dst11_seg17_res dst11_seg18 5.100000e-11
c_lev4_src6_dst11_seg17 dst11_seg18 0 4.900000e-15

r_lev4_src6_dst11_seg18 dst11_seg18 dst11_seg18_res 2.550000e-01
l_lev4_src6_dst11_seg18 dst11_seg18_res dst11_seg19 5.100000e-11
c_lev4_src6_dst11_seg18 dst11_seg19 0 4.900000e-15

r_lev4_src6_dst11_seg19 dst11_seg19 dst11_seg19_res 2.550000e-01
l_lev4_src6_dst11_seg19 dst11_seg19_res dst11_seg20 5.100000e-11
c_lev4_src6_dst11_seg19 dst11_seg20 0 4.900000e-15

r_lev4_src6_dst11_seg20 dst11_seg20 dst11_seg20_res 2.550000e-01
l_lev4_src6_dst11_seg20 dst11_seg20_res dst11_seg21 5.100000e-11
c_lev4_src6_dst11_seg20 dst11_seg21 0 4.900000e-15

r_lev4_src6_dst11_seg21 dst11_seg21 dst11_seg21_res 2.550000e-01
l_lev4_src6_dst11_seg21 dst11_seg21_res dst11_seg22 5.100000e-11
c_lev4_src6_dst11_seg21 dst11_seg22 0 4.900000e-15

r_lev4_src6_dst11_seg22 dst11_seg22 dst11_seg22_res 2.550000e-01
l_lev4_src6_dst11_seg22 dst11_seg22_res dst11_seg23 5.100000e-11
c_lev4_src6_dst11_seg22 dst11_seg23 0 4.900000e-15

r_lev4_src6_dst11_seg23 dst11_seg23 dst11_seg23_res 2.550000e-01
l_lev4_src6_dst11_seg23 dst11_seg23_res dst11_seg24 5.100000e-11
c_lev4_src6_dst11_seg23 dst11_seg24 0 4.900000e-15

r_lev4_src6_dst11_seg24 dst11_seg24 dst11_seg24_res 2.550000e-01
l_lev4_src6_dst11_seg24 dst11_seg24_res dst11_seg25 5.100000e-11
c_lev4_src6_dst11_seg24 dst11_seg25 0 4.900000e-15

r_lev4_src6_dst11_seg25 dst11_seg25 dst11_seg25_res 2.550000e-01
l_lev4_src6_dst11_seg25 dst11_seg25_res dst11_seg26 5.100000e-11
c_lev4_src6_dst11_seg25 dst11_seg26 0 4.900000e-15

r_lev4_src6_dst11_seg26 dst11_seg26 dst11_seg26_res 2.550000e-01
l_lev4_src6_dst11_seg26 dst11_seg26_res dst11_seg27 5.100000e-11
c_lev4_src6_dst11_seg26 dst11_seg27 0 4.900000e-15

r_lev4_src6_dst11_seg27 dst11_seg27 dst11_seg27_res 2.550000e-01
l_lev4_src6_dst11_seg27 dst11_seg27_res dst11_seg28 5.100000e-11
c_lev4_src6_dst11_seg27 dst11_seg28 0 4.900000e-15

r_lev4_src6_dst11_seg28 dst11_seg28 dst11_seg28_res 2.550000e-01
l_lev4_src6_dst11_seg28 dst11_seg28_res dst11_seg29 5.100000e-11
c_lev4_src6_dst11_seg28 dst11_seg29 0 4.900000e-15

r_lev4_src6_dst11_seg29 dst11_seg29 dst11_seg29_res 2.550000e-01
l_lev4_src6_dst11_seg29 dst11_seg29_res dst11_seg30 5.100000e-11
c_lev4_src6_dst11_seg29 dst11_seg30 0 4.900000e-15

r_lev4_src6_dst11_seg30 dst11_seg30 dst11_seg30_res 2.550000e-01
l_lev4_src6_dst11_seg30 dst11_seg30_res dst11_seg31 5.100000e-11
c_lev4_src6_dst11_seg30 dst11_seg31 0 4.900000e-15

r_lev4_src6_dst11_seg31 dst11_seg31 dst11_seg31_res 2.550000e-01
l_lev4_src6_dst11_seg31 dst11_seg31_res dst11_seg32 5.100000e-11
c_lev4_src6_dst11_seg31 dst11_seg32 0 4.900000e-15

r_lev4_src6_dst11_seg32 dst11_seg32 dst11_seg32_res 2.550000e-01
l_lev4_src6_dst11_seg32 dst11_seg32_res dst11_seg33 5.100000e-11
c_lev4_src6_dst11_seg32 dst11_seg33 0 4.900000e-15

r_lev4_src6_dst11_seg33 dst11_seg33 dst11_seg33_res 2.550000e-01
l_lev4_src6_dst11_seg33 dst11_seg33_res dst11_seg34 5.100000e-11
c_lev4_src6_dst11_seg33 dst11_seg34 0 4.900000e-15

r_lev4_src6_dst11_seg34 dst11_seg34 dst11_seg34_res 2.550000e-01
l_lev4_src6_dst11_seg34 dst11_seg34_res dst11_seg35 5.100000e-11
c_lev4_src6_dst11_seg34 dst11_seg35 0 4.900000e-15

r_lev4_src6_dst11_seg35 dst11_seg35 dst11_seg35_res 2.550000e-01
l_lev4_src6_dst11_seg35 dst11_seg35_res dst11_seg36 5.100000e-11
c_lev4_src6_dst11_seg35 dst11_seg36 0 4.900000e-15

r_lev4_src6_dst11_seg36 dst11_seg36 dst11_seg36_res 2.550000e-01
l_lev4_src6_dst11_seg36 dst11_seg36_res dst11_seg37 5.100000e-11
c_lev4_src6_dst11_seg36 dst11_seg37 0 4.900000e-15

r_lev4_src6_dst11_seg37 dst11_seg37 dst11_seg37_res 2.550000e-01
l_lev4_src6_dst11_seg37 dst11_seg37_res dst11_seg38 5.100000e-11
c_lev4_src6_dst11_seg37 dst11_seg38 0 4.900000e-15

r_lev4_src6_dst11_seg38 dst11_seg38 dst11_seg38_res 2.550000e-01
l_lev4_src6_dst11_seg38 dst11_seg38_res dst11_seg39 5.100000e-11
c_lev4_src6_dst11_seg38 dst11_seg39 0 4.900000e-15

r_lev4_src6_dst11_seg39 dst11_seg39 dst11_seg39_res 2.550000e-01
l_lev4_src6_dst11_seg39 dst11_seg39_res dst11_seg40 5.100000e-11
c_lev4_src6_dst11_seg39 dst11_seg40 0 4.900000e-15

r_lev4_src6_dst11_seg40 dst11_seg40 dst11_seg40_res 2.550000e-01
l_lev4_src6_dst11_seg40 dst11_seg40_res pt11 5.100000e-11
c_lev4_src6_dst11_seg40 pt11 0 4.900000e-15

r_lev4_dst11_load pt11 0 5.000000e+03
c_lev4_dst11_load pt11 0 5.000000e-15

r_lev4_src6_dst12_seg1 pt6 dst12_seg1_res 2.550000e-01
l_lev4_src6_dst12_seg1 dst12_seg1_res dst12_seg2 5.100000e-11
c_lev4_src6_dst12_seg1 dst12_seg2 0 4.900000e-15

r_lev4_src6_dst12_seg2 dst12_seg2 dst12_seg2_res 2.550000e-01
l_lev4_src6_dst12_seg2 dst12_seg2_res dst12_seg3 5.100000e-11
c_lev4_src6_dst12_seg2 dst12_seg3 0 4.900000e-15

r_lev4_src6_dst12_seg3 dst12_seg3 dst12_seg3_res 2.550000e-01
l_lev4_src6_dst12_seg3 dst12_seg3_res dst12_seg4 5.100000e-11
c_lev4_src6_dst12_seg3 dst12_seg4 0 4.900000e-15

r_lev4_src6_dst12_seg4 dst12_seg4 dst12_seg4_res 2.550000e-01
l_lev4_src6_dst12_seg4 dst12_seg4_res dst12_seg5 5.100000e-11
c_lev4_src6_dst12_seg4 dst12_seg5 0 4.900000e-15

r_lev4_src6_dst12_seg5 dst12_seg5 dst12_seg5_res 2.550000e-01
l_lev4_src6_dst12_seg5 dst12_seg5_res dst12_seg6 5.100000e-11
c_lev4_src6_dst12_seg5 dst12_seg6 0 4.900000e-15

r_lev4_src6_dst12_seg6 dst12_seg6 dst12_seg6_res 2.550000e-01
l_lev4_src6_dst12_seg6 dst12_seg6_res dst12_seg7 5.100000e-11
c_lev4_src6_dst12_seg6 dst12_seg7 0 4.900000e-15

r_lev4_src6_dst12_seg7 dst12_seg7 dst12_seg7_res 2.550000e-01
l_lev4_src6_dst12_seg7 dst12_seg7_res dst12_seg8 5.100000e-11
c_lev4_src6_dst12_seg7 dst12_seg8 0 4.900000e-15

r_lev4_src6_dst12_seg8 dst12_seg8 dst12_seg8_res 2.550000e-01
l_lev4_src6_dst12_seg8 dst12_seg8_res dst12_seg9 5.100000e-11
c_lev4_src6_dst12_seg8 dst12_seg9 0 4.900000e-15

r_lev4_src6_dst12_seg9 dst12_seg9 dst12_seg9_res 2.550000e-01
l_lev4_src6_dst12_seg9 dst12_seg9_res dst12_seg10 5.100000e-11
c_lev4_src6_dst12_seg9 dst12_seg10 0 4.900000e-15

r_lev4_src6_dst12_seg10 dst12_seg10 dst12_seg10_res 2.550000e-01
l_lev4_src6_dst12_seg10 dst12_seg10_res dst12_seg11 5.100000e-11
c_lev4_src6_dst12_seg10 dst12_seg11 0 4.900000e-15

r_lev4_src6_dst12_seg11 dst12_seg11 dst12_seg11_res 2.550000e-01
l_lev4_src6_dst12_seg11 dst12_seg11_res dst12_seg12 5.100000e-11
c_lev4_src6_dst12_seg11 dst12_seg12 0 4.900000e-15

r_lev4_src6_dst12_seg12 dst12_seg12 dst12_seg12_res 2.550000e-01
l_lev4_src6_dst12_seg12 dst12_seg12_res dst12_seg13 5.100000e-11
c_lev4_src6_dst12_seg12 dst12_seg13 0 4.900000e-15

r_lev4_src6_dst12_seg13 dst12_seg13 dst12_seg13_res 2.550000e-01
l_lev4_src6_dst12_seg13 dst12_seg13_res dst12_seg14 5.100000e-11
c_lev4_src6_dst12_seg13 dst12_seg14 0 4.900000e-15

r_lev4_src6_dst12_seg14 dst12_seg14 dst12_seg14_res 2.550000e-01
l_lev4_src6_dst12_seg14 dst12_seg14_res dst12_seg15 5.100000e-11
c_lev4_src6_dst12_seg14 dst12_seg15 0 4.900000e-15

r_lev4_src6_dst12_seg15 dst12_seg15 dst12_seg15_res 2.550000e-01
l_lev4_src6_dst12_seg15 dst12_seg15_res dst12_seg16 5.100000e-11
c_lev4_src6_dst12_seg15 dst12_seg16 0 4.900000e-15

r_lev4_src6_dst12_seg16 dst12_seg16 dst12_seg16_res 2.550000e-01
l_lev4_src6_dst12_seg16 dst12_seg16_res dst12_seg17 5.100000e-11
c_lev4_src6_dst12_seg16 dst12_seg17 0 4.900000e-15

r_lev4_src6_dst12_seg17 dst12_seg17 dst12_seg17_res 2.550000e-01
l_lev4_src6_dst12_seg17 dst12_seg17_res dst12_seg18 5.100000e-11
c_lev4_src6_dst12_seg17 dst12_seg18 0 4.900000e-15

r_lev4_src6_dst12_seg18 dst12_seg18 dst12_seg18_res 2.550000e-01
l_lev4_src6_dst12_seg18 dst12_seg18_res dst12_seg19 5.100000e-11
c_lev4_src6_dst12_seg18 dst12_seg19 0 4.900000e-15

r_lev4_src6_dst12_seg19 dst12_seg19 dst12_seg19_res 2.550000e-01
l_lev4_src6_dst12_seg19 dst12_seg19_res dst12_seg20 5.100000e-11
c_lev4_src6_dst12_seg19 dst12_seg20 0 4.900000e-15

r_lev4_src6_dst12_seg20 dst12_seg20 dst12_seg20_res 2.550000e-01
l_lev4_src6_dst12_seg20 dst12_seg20_res dst12_seg21 5.100000e-11
c_lev4_src6_dst12_seg20 dst12_seg21 0 4.900000e-15

r_lev4_src6_dst12_seg21 dst12_seg21 dst12_seg21_res 2.550000e-01
l_lev4_src6_dst12_seg21 dst12_seg21_res dst12_seg22 5.100000e-11
c_lev4_src6_dst12_seg21 dst12_seg22 0 4.900000e-15

r_lev4_src6_dst12_seg22 dst12_seg22 dst12_seg22_res 2.550000e-01
l_lev4_src6_dst12_seg22 dst12_seg22_res dst12_seg23 5.100000e-11
c_lev4_src6_dst12_seg22 dst12_seg23 0 4.900000e-15

r_lev4_src6_dst12_seg23 dst12_seg23 dst12_seg23_res 2.550000e-01
l_lev4_src6_dst12_seg23 dst12_seg23_res dst12_seg24 5.100000e-11
c_lev4_src6_dst12_seg23 dst12_seg24 0 4.900000e-15

r_lev4_src6_dst12_seg24 dst12_seg24 dst12_seg24_res 2.550000e-01
l_lev4_src6_dst12_seg24 dst12_seg24_res dst12_seg25 5.100000e-11
c_lev4_src6_dst12_seg24 dst12_seg25 0 4.900000e-15

r_lev4_src6_dst12_seg25 dst12_seg25 dst12_seg25_res 2.550000e-01
l_lev4_src6_dst12_seg25 dst12_seg25_res dst12_seg26 5.100000e-11
c_lev4_src6_dst12_seg25 dst12_seg26 0 4.900000e-15

r_lev4_src6_dst12_seg26 dst12_seg26 dst12_seg26_res 2.550000e-01
l_lev4_src6_dst12_seg26 dst12_seg26_res dst12_seg27 5.100000e-11
c_lev4_src6_dst12_seg26 dst12_seg27 0 4.900000e-15

r_lev4_src6_dst12_seg27 dst12_seg27 dst12_seg27_res 2.550000e-01
l_lev4_src6_dst12_seg27 dst12_seg27_res dst12_seg28 5.100000e-11
c_lev4_src6_dst12_seg27 dst12_seg28 0 4.900000e-15

r_lev4_src6_dst12_seg28 dst12_seg28 dst12_seg28_res 2.550000e-01
l_lev4_src6_dst12_seg28 dst12_seg28_res dst12_seg29 5.100000e-11
c_lev4_src6_dst12_seg28 dst12_seg29 0 4.900000e-15

r_lev4_src6_dst12_seg29 dst12_seg29 dst12_seg29_res 2.550000e-01
l_lev4_src6_dst12_seg29 dst12_seg29_res dst12_seg30 5.100000e-11
c_lev4_src6_dst12_seg29 dst12_seg30 0 4.900000e-15

r_lev4_src6_dst12_seg30 dst12_seg30 dst12_seg30_res 2.550000e-01
l_lev4_src6_dst12_seg30 dst12_seg30_res dst12_seg31 5.100000e-11
c_lev4_src6_dst12_seg30 dst12_seg31 0 4.900000e-15

r_lev4_src6_dst12_seg31 dst12_seg31 dst12_seg31_res 2.550000e-01
l_lev4_src6_dst12_seg31 dst12_seg31_res dst12_seg32 5.100000e-11
c_lev4_src6_dst12_seg31 dst12_seg32 0 4.900000e-15

r_lev4_src6_dst12_seg32 dst12_seg32 dst12_seg32_res 2.550000e-01
l_lev4_src6_dst12_seg32 dst12_seg32_res dst12_seg33 5.100000e-11
c_lev4_src6_dst12_seg32 dst12_seg33 0 4.900000e-15

r_lev4_src6_dst12_seg33 dst12_seg33 dst12_seg33_res 2.550000e-01
l_lev4_src6_dst12_seg33 dst12_seg33_res dst12_seg34 5.100000e-11
c_lev4_src6_dst12_seg33 dst12_seg34 0 4.900000e-15

r_lev4_src6_dst12_seg34 dst12_seg34 dst12_seg34_res 2.550000e-01
l_lev4_src6_dst12_seg34 dst12_seg34_res dst12_seg35 5.100000e-11
c_lev4_src6_dst12_seg34 dst12_seg35 0 4.900000e-15

r_lev4_src6_dst12_seg35 dst12_seg35 dst12_seg35_res 2.550000e-01
l_lev4_src6_dst12_seg35 dst12_seg35_res dst12_seg36 5.100000e-11
c_lev4_src6_dst12_seg35 dst12_seg36 0 4.900000e-15

r_lev4_src6_dst12_seg36 dst12_seg36 dst12_seg36_res 2.550000e-01
l_lev4_src6_dst12_seg36 dst12_seg36_res dst12_seg37 5.100000e-11
c_lev4_src6_dst12_seg36 dst12_seg37 0 4.900000e-15

r_lev4_src6_dst12_seg37 dst12_seg37 dst12_seg37_res 2.550000e-01
l_lev4_src6_dst12_seg37 dst12_seg37_res dst12_seg38 5.100000e-11
c_lev4_src6_dst12_seg37 dst12_seg38 0 4.900000e-15

r_lev4_src6_dst12_seg38 dst12_seg38 dst12_seg38_res 2.550000e-01
l_lev4_src6_dst12_seg38 dst12_seg38_res dst12_seg39 5.100000e-11
c_lev4_src6_dst12_seg38 dst12_seg39 0 4.900000e-15

r_lev4_src6_dst12_seg39 dst12_seg39 dst12_seg39_res 2.550000e-01
l_lev4_src6_dst12_seg39 dst12_seg39_res dst12_seg40 5.100000e-11
c_lev4_src6_dst12_seg39 dst12_seg40 0 4.900000e-15

r_lev4_src6_dst12_seg40 dst12_seg40 dst12_seg40_res 2.550000e-01
l_lev4_src6_dst12_seg40 dst12_seg40_res pt12 5.100000e-11
c_lev4_src6_dst12_seg40 pt12 0 4.900000e-15

r_lev4_dst12_load pt12 0 5.000000e+03
c_lev4_dst12_load pt12 0 5.000000e-15

r_lev4_src7_dst13_seg1 pt7 dst13_seg1_res 2.550000e-01
l_lev4_src7_dst13_seg1 dst13_seg1_res dst13_seg2 5.100000e-11
c_lev4_src7_dst13_seg1 dst13_seg2 0 4.900000e-15

r_lev4_src7_dst13_seg2 dst13_seg2 dst13_seg2_res 2.550000e-01
l_lev4_src7_dst13_seg2 dst13_seg2_res dst13_seg3 5.100000e-11
c_lev4_src7_dst13_seg2 dst13_seg3 0 4.900000e-15

r_lev4_src7_dst13_seg3 dst13_seg3 dst13_seg3_res 2.550000e-01
l_lev4_src7_dst13_seg3 dst13_seg3_res dst13_seg4 5.100000e-11
c_lev4_src7_dst13_seg3 dst13_seg4 0 4.900000e-15

r_lev4_src7_dst13_seg4 dst13_seg4 dst13_seg4_res 2.550000e-01
l_lev4_src7_dst13_seg4 dst13_seg4_res dst13_seg5 5.100000e-11
c_lev4_src7_dst13_seg4 dst13_seg5 0 4.900000e-15

r_lev4_src7_dst13_seg5 dst13_seg5 dst13_seg5_res 2.550000e-01
l_lev4_src7_dst13_seg5 dst13_seg5_res dst13_seg6 5.100000e-11
c_lev4_src7_dst13_seg5 dst13_seg6 0 4.900000e-15

r_lev4_src7_dst13_seg6 dst13_seg6 dst13_seg6_res 2.550000e-01
l_lev4_src7_dst13_seg6 dst13_seg6_res dst13_seg7 5.100000e-11
c_lev4_src7_dst13_seg6 dst13_seg7 0 4.900000e-15

r_lev4_src7_dst13_seg7 dst13_seg7 dst13_seg7_res 2.550000e-01
l_lev4_src7_dst13_seg7 dst13_seg7_res dst13_seg8 5.100000e-11
c_lev4_src7_dst13_seg7 dst13_seg8 0 4.900000e-15

r_lev4_src7_dst13_seg8 dst13_seg8 dst13_seg8_res 2.550000e-01
l_lev4_src7_dst13_seg8 dst13_seg8_res dst13_seg9 5.100000e-11
c_lev4_src7_dst13_seg8 dst13_seg9 0 4.900000e-15

r_lev4_src7_dst13_seg9 dst13_seg9 dst13_seg9_res 2.550000e-01
l_lev4_src7_dst13_seg9 dst13_seg9_res dst13_seg10 5.100000e-11
c_lev4_src7_dst13_seg9 dst13_seg10 0 4.900000e-15

r_lev4_src7_dst13_seg10 dst13_seg10 dst13_seg10_res 2.550000e-01
l_lev4_src7_dst13_seg10 dst13_seg10_res dst13_seg11 5.100000e-11
c_lev4_src7_dst13_seg10 dst13_seg11 0 4.900000e-15

r_lev4_src7_dst13_seg11 dst13_seg11 dst13_seg11_res 2.550000e-01
l_lev4_src7_dst13_seg11 dst13_seg11_res dst13_seg12 5.100000e-11
c_lev4_src7_dst13_seg11 dst13_seg12 0 4.900000e-15

r_lev4_src7_dst13_seg12 dst13_seg12 dst13_seg12_res 2.550000e-01
l_lev4_src7_dst13_seg12 dst13_seg12_res dst13_seg13 5.100000e-11
c_lev4_src7_dst13_seg12 dst13_seg13 0 4.900000e-15

r_lev4_src7_dst13_seg13 dst13_seg13 dst13_seg13_res 2.550000e-01
l_lev4_src7_dst13_seg13 dst13_seg13_res dst13_seg14 5.100000e-11
c_lev4_src7_dst13_seg13 dst13_seg14 0 4.900000e-15

r_lev4_src7_dst13_seg14 dst13_seg14 dst13_seg14_res 2.550000e-01
l_lev4_src7_dst13_seg14 dst13_seg14_res dst13_seg15 5.100000e-11
c_lev4_src7_dst13_seg14 dst13_seg15 0 4.900000e-15

r_lev4_src7_dst13_seg15 dst13_seg15 dst13_seg15_res 2.550000e-01
l_lev4_src7_dst13_seg15 dst13_seg15_res dst13_seg16 5.100000e-11
c_lev4_src7_dst13_seg15 dst13_seg16 0 4.900000e-15

r_lev4_src7_dst13_seg16 dst13_seg16 dst13_seg16_res 2.550000e-01
l_lev4_src7_dst13_seg16 dst13_seg16_res dst13_seg17 5.100000e-11
c_lev4_src7_dst13_seg16 dst13_seg17 0 4.900000e-15

r_lev4_src7_dst13_seg17 dst13_seg17 dst13_seg17_res 2.550000e-01
l_lev4_src7_dst13_seg17 dst13_seg17_res dst13_seg18 5.100000e-11
c_lev4_src7_dst13_seg17 dst13_seg18 0 4.900000e-15

r_lev4_src7_dst13_seg18 dst13_seg18 dst13_seg18_res 2.550000e-01
l_lev4_src7_dst13_seg18 dst13_seg18_res dst13_seg19 5.100000e-11
c_lev4_src7_dst13_seg18 dst13_seg19 0 4.900000e-15

r_lev4_src7_dst13_seg19 dst13_seg19 dst13_seg19_res 2.550000e-01
l_lev4_src7_dst13_seg19 dst13_seg19_res dst13_seg20 5.100000e-11
c_lev4_src7_dst13_seg19 dst13_seg20 0 4.900000e-15

r_lev4_src7_dst13_seg20 dst13_seg20 dst13_seg20_res 2.550000e-01
l_lev4_src7_dst13_seg20 dst13_seg20_res dst13_seg21 5.100000e-11
c_lev4_src7_dst13_seg20 dst13_seg21 0 4.900000e-15

r_lev4_src7_dst13_seg21 dst13_seg21 dst13_seg21_res 2.550000e-01
l_lev4_src7_dst13_seg21 dst13_seg21_res dst13_seg22 5.100000e-11
c_lev4_src7_dst13_seg21 dst13_seg22 0 4.900000e-15

r_lev4_src7_dst13_seg22 dst13_seg22 dst13_seg22_res 2.550000e-01
l_lev4_src7_dst13_seg22 dst13_seg22_res dst13_seg23 5.100000e-11
c_lev4_src7_dst13_seg22 dst13_seg23 0 4.900000e-15

r_lev4_src7_dst13_seg23 dst13_seg23 dst13_seg23_res 2.550000e-01
l_lev4_src7_dst13_seg23 dst13_seg23_res dst13_seg24 5.100000e-11
c_lev4_src7_dst13_seg23 dst13_seg24 0 4.900000e-15

r_lev4_src7_dst13_seg24 dst13_seg24 dst13_seg24_res 2.550000e-01
l_lev4_src7_dst13_seg24 dst13_seg24_res dst13_seg25 5.100000e-11
c_lev4_src7_dst13_seg24 dst13_seg25 0 4.900000e-15

r_lev4_src7_dst13_seg25 dst13_seg25 dst13_seg25_res 2.550000e-01
l_lev4_src7_dst13_seg25 dst13_seg25_res dst13_seg26 5.100000e-11
c_lev4_src7_dst13_seg25 dst13_seg26 0 4.900000e-15

r_lev4_src7_dst13_seg26 dst13_seg26 dst13_seg26_res 2.550000e-01
l_lev4_src7_dst13_seg26 dst13_seg26_res dst13_seg27 5.100000e-11
c_lev4_src7_dst13_seg26 dst13_seg27 0 4.900000e-15

r_lev4_src7_dst13_seg27 dst13_seg27 dst13_seg27_res 2.550000e-01
l_lev4_src7_dst13_seg27 dst13_seg27_res dst13_seg28 5.100000e-11
c_lev4_src7_dst13_seg27 dst13_seg28 0 4.900000e-15

r_lev4_src7_dst13_seg28 dst13_seg28 dst13_seg28_res 2.550000e-01
l_lev4_src7_dst13_seg28 dst13_seg28_res dst13_seg29 5.100000e-11
c_lev4_src7_dst13_seg28 dst13_seg29 0 4.900000e-15

r_lev4_src7_dst13_seg29 dst13_seg29 dst13_seg29_res 2.550000e-01
l_lev4_src7_dst13_seg29 dst13_seg29_res dst13_seg30 5.100000e-11
c_lev4_src7_dst13_seg29 dst13_seg30 0 4.900000e-15

r_lev4_src7_dst13_seg30 dst13_seg30 dst13_seg30_res 2.550000e-01
l_lev4_src7_dst13_seg30 dst13_seg30_res dst13_seg31 5.100000e-11
c_lev4_src7_dst13_seg30 dst13_seg31 0 4.900000e-15

r_lev4_src7_dst13_seg31 dst13_seg31 dst13_seg31_res 2.550000e-01
l_lev4_src7_dst13_seg31 dst13_seg31_res dst13_seg32 5.100000e-11
c_lev4_src7_dst13_seg31 dst13_seg32 0 4.900000e-15

r_lev4_src7_dst13_seg32 dst13_seg32 dst13_seg32_res 2.550000e-01
l_lev4_src7_dst13_seg32 dst13_seg32_res dst13_seg33 5.100000e-11
c_lev4_src7_dst13_seg32 dst13_seg33 0 4.900000e-15

r_lev4_src7_dst13_seg33 dst13_seg33 dst13_seg33_res 2.550000e-01
l_lev4_src7_dst13_seg33 dst13_seg33_res dst13_seg34 5.100000e-11
c_lev4_src7_dst13_seg33 dst13_seg34 0 4.900000e-15

r_lev4_src7_dst13_seg34 dst13_seg34 dst13_seg34_res 2.550000e-01
l_lev4_src7_dst13_seg34 dst13_seg34_res dst13_seg35 5.100000e-11
c_lev4_src7_dst13_seg34 dst13_seg35 0 4.900000e-15

r_lev4_src7_dst13_seg35 dst13_seg35 dst13_seg35_res 2.550000e-01
l_lev4_src7_dst13_seg35 dst13_seg35_res dst13_seg36 5.100000e-11
c_lev4_src7_dst13_seg35 dst13_seg36 0 4.900000e-15

r_lev4_src7_dst13_seg36 dst13_seg36 dst13_seg36_res 2.550000e-01
l_lev4_src7_dst13_seg36 dst13_seg36_res dst13_seg37 5.100000e-11
c_lev4_src7_dst13_seg36 dst13_seg37 0 4.900000e-15

r_lev4_src7_dst13_seg37 dst13_seg37 dst13_seg37_res 2.550000e-01
l_lev4_src7_dst13_seg37 dst13_seg37_res dst13_seg38 5.100000e-11
c_lev4_src7_dst13_seg37 dst13_seg38 0 4.900000e-15

r_lev4_src7_dst13_seg38 dst13_seg38 dst13_seg38_res 2.550000e-01
l_lev4_src7_dst13_seg38 dst13_seg38_res dst13_seg39 5.100000e-11
c_lev4_src7_dst13_seg38 dst13_seg39 0 4.900000e-15

r_lev4_src7_dst13_seg39 dst13_seg39 dst13_seg39_res 2.550000e-01
l_lev4_src7_dst13_seg39 dst13_seg39_res dst13_seg40 5.100000e-11
c_lev4_src7_dst13_seg39 dst13_seg40 0 4.900000e-15

r_lev4_src7_dst13_seg40 dst13_seg40 dst13_seg40_res 2.550000e-01
l_lev4_src7_dst13_seg40 dst13_seg40_res pt13 5.100000e-11
c_lev4_src7_dst13_seg40 pt13 0 4.900000e-15

r_lev4_dst13_load pt13 0 5.000000e+03
c_lev4_dst13_load pt13 0 5.000000e-15

r_lev4_src7_dst14_seg1 pt7 dst14_seg1_res 2.550000e-01
l_lev4_src7_dst14_seg1 dst14_seg1_res dst14_seg2 5.100000e-11
c_lev4_src7_dst14_seg1 dst14_seg2 0 4.900000e-15

r_lev4_src7_dst14_seg2 dst14_seg2 dst14_seg2_res 2.550000e-01
l_lev4_src7_dst14_seg2 dst14_seg2_res dst14_seg3 5.100000e-11
c_lev4_src7_dst14_seg2 dst14_seg3 0 4.900000e-15

r_lev4_src7_dst14_seg3 dst14_seg3 dst14_seg3_res 2.550000e-01
l_lev4_src7_dst14_seg3 dst14_seg3_res dst14_seg4 5.100000e-11
c_lev4_src7_dst14_seg3 dst14_seg4 0 4.900000e-15

r_lev4_src7_dst14_seg4 dst14_seg4 dst14_seg4_res 2.550000e-01
l_lev4_src7_dst14_seg4 dst14_seg4_res dst14_seg5 5.100000e-11
c_lev4_src7_dst14_seg4 dst14_seg5 0 4.900000e-15

r_lev4_src7_dst14_seg5 dst14_seg5 dst14_seg5_res 2.550000e-01
l_lev4_src7_dst14_seg5 dst14_seg5_res dst14_seg6 5.100000e-11
c_lev4_src7_dst14_seg5 dst14_seg6 0 4.900000e-15

r_lev4_src7_dst14_seg6 dst14_seg6 dst14_seg6_res 2.550000e-01
l_lev4_src7_dst14_seg6 dst14_seg6_res dst14_seg7 5.100000e-11
c_lev4_src7_dst14_seg6 dst14_seg7 0 4.900000e-15

r_lev4_src7_dst14_seg7 dst14_seg7 dst14_seg7_res 2.550000e-01
l_lev4_src7_dst14_seg7 dst14_seg7_res dst14_seg8 5.100000e-11
c_lev4_src7_dst14_seg7 dst14_seg8 0 4.900000e-15

r_lev4_src7_dst14_seg8 dst14_seg8 dst14_seg8_res 2.550000e-01
l_lev4_src7_dst14_seg8 dst14_seg8_res dst14_seg9 5.100000e-11
c_lev4_src7_dst14_seg8 dst14_seg9 0 4.900000e-15

r_lev4_src7_dst14_seg9 dst14_seg9 dst14_seg9_res 2.550000e-01
l_lev4_src7_dst14_seg9 dst14_seg9_res dst14_seg10 5.100000e-11
c_lev4_src7_dst14_seg9 dst14_seg10 0 4.900000e-15

r_lev4_src7_dst14_seg10 dst14_seg10 dst14_seg10_res 2.550000e-01
l_lev4_src7_dst14_seg10 dst14_seg10_res dst14_seg11 5.100000e-11
c_lev4_src7_dst14_seg10 dst14_seg11 0 4.900000e-15

r_lev4_src7_dst14_seg11 dst14_seg11 dst14_seg11_res 2.550000e-01
l_lev4_src7_dst14_seg11 dst14_seg11_res dst14_seg12 5.100000e-11
c_lev4_src7_dst14_seg11 dst14_seg12 0 4.900000e-15

r_lev4_src7_dst14_seg12 dst14_seg12 dst14_seg12_res 2.550000e-01
l_lev4_src7_dst14_seg12 dst14_seg12_res dst14_seg13 5.100000e-11
c_lev4_src7_dst14_seg12 dst14_seg13 0 4.900000e-15

r_lev4_src7_dst14_seg13 dst14_seg13 dst14_seg13_res 2.550000e-01
l_lev4_src7_dst14_seg13 dst14_seg13_res dst14_seg14 5.100000e-11
c_lev4_src7_dst14_seg13 dst14_seg14 0 4.900000e-15

r_lev4_src7_dst14_seg14 dst14_seg14 dst14_seg14_res 2.550000e-01
l_lev4_src7_dst14_seg14 dst14_seg14_res dst14_seg15 5.100000e-11
c_lev4_src7_dst14_seg14 dst14_seg15 0 4.900000e-15

r_lev4_src7_dst14_seg15 dst14_seg15 dst14_seg15_res 2.550000e-01
l_lev4_src7_dst14_seg15 dst14_seg15_res dst14_seg16 5.100000e-11
c_lev4_src7_dst14_seg15 dst14_seg16 0 4.900000e-15

r_lev4_src7_dst14_seg16 dst14_seg16 dst14_seg16_res 2.550000e-01
l_lev4_src7_dst14_seg16 dst14_seg16_res dst14_seg17 5.100000e-11
c_lev4_src7_dst14_seg16 dst14_seg17 0 4.900000e-15

r_lev4_src7_dst14_seg17 dst14_seg17 dst14_seg17_res 2.550000e-01
l_lev4_src7_dst14_seg17 dst14_seg17_res dst14_seg18 5.100000e-11
c_lev4_src7_dst14_seg17 dst14_seg18 0 4.900000e-15

r_lev4_src7_dst14_seg18 dst14_seg18 dst14_seg18_res 2.550000e-01
l_lev4_src7_dst14_seg18 dst14_seg18_res dst14_seg19 5.100000e-11
c_lev4_src7_dst14_seg18 dst14_seg19 0 4.900000e-15

r_lev4_src7_dst14_seg19 dst14_seg19 dst14_seg19_res 2.550000e-01
l_lev4_src7_dst14_seg19 dst14_seg19_res dst14_seg20 5.100000e-11
c_lev4_src7_dst14_seg19 dst14_seg20 0 4.900000e-15

r_lev4_src7_dst14_seg20 dst14_seg20 dst14_seg20_res 2.550000e-01
l_lev4_src7_dst14_seg20 dst14_seg20_res dst14_seg21 5.100000e-11
c_lev4_src7_dst14_seg20 dst14_seg21 0 4.900000e-15

r_lev4_src7_dst14_seg21 dst14_seg21 dst14_seg21_res 2.550000e-01
l_lev4_src7_dst14_seg21 dst14_seg21_res dst14_seg22 5.100000e-11
c_lev4_src7_dst14_seg21 dst14_seg22 0 4.900000e-15

r_lev4_src7_dst14_seg22 dst14_seg22 dst14_seg22_res 2.550000e-01
l_lev4_src7_dst14_seg22 dst14_seg22_res dst14_seg23 5.100000e-11
c_lev4_src7_dst14_seg22 dst14_seg23 0 4.900000e-15

r_lev4_src7_dst14_seg23 dst14_seg23 dst14_seg23_res 2.550000e-01
l_lev4_src7_dst14_seg23 dst14_seg23_res dst14_seg24 5.100000e-11
c_lev4_src7_dst14_seg23 dst14_seg24 0 4.900000e-15

r_lev4_src7_dst14_seg24 dst14_seg24 dst14_seg24_res 2.550000e-01
l_lev4_src7_dst14_seg24 dst14_seg24_res dst14_seg25 5.100000e-11
c_lev4_src7_dst14_seg24 dst14_seg25 0 4.900000e-15

r_lev4_src7_dst14_seg25 dst14_seg25 dst14_seg25_res 2.550000e-01
l_lev4_src7_dst14_seg25 dst14_seg25_res dst14_seg26 5.100000e-11
c_lev4_src7_dst14_seg25 dst14_seg26 0 4.900000e-15

r_lev4_src7_dst14_seg26 dst14_seg26 dst14_seg26_res 2.550000e-01
l_lev4_src7_dst14_seg26 dst14_seg26_res dst14_seg27 5.100000e-11
c_lev4_src7_dst14_seg26 dst14_seg27 0 4.900000e-15

r_lev4_src7_dst14_seg27 dst14_seg27 dst14_seg27_res 2.550000e-01
l_lev4_src7_dst14_seg27 dst14_seg27_res dst14_seg28 5.100000e-11
c_lev4_src7_dst14_seg27 dst14_seg28 0 4.900000e-15

r_lev4_src7_dst14_seg28 dst14_seg28 dst14_seg28_res 2.550000e-01
l_lev4_src7_dst14_seg28 dst14_seg28_res dst14_seg29 5.100000e-11
c_lev4_src7_dst14_seg28 dst14_seg29 0 4.900000e-15

r_lev4_src7_dst14_seg29 dst14_seg29 dst14_seg29_res 2.550000e-01
l_lev4_src7_dst14_seg29 dst14_seg29_res dst14_seg30 5.100000e-11
c_lev4_src7_dst14_seg29 dst14_seg30 0 4.900000e-15

r_lev4_src7_dst14_seg30 dst14_seg30 dst14_seg30_res 2.550000e-01
l_lev4_src7_dst14_seg30 dst14_seg30_res dst14_seg31 5.100000e-11
c_lev4_src7_dst14_seg30 dst14_seg31 0 4.900000e-15

r_lev4_src7_dst14_seg31 dst14_seg31 dst14_seg31_res 2.550000e-01
l_lev4_src7_dst14_seg31 dst14_seg31_res dst14_seg32 5.100000e-11
c_lev4_src7_dst14_seg31 dst14_seg32 0 4.900000e-15

r_lev4_src7_dst14_seg32 dst14_seg32 dst14_seg32_res 2.550000e-01
l_lev4_src7_dst14_seg32 dst14_seg32_res dst14_seg33 5.100000e-11
c_lev4_src7_dst14_seg32 dst14_seg33 0 4.900000e-15

r_lev4_src7_dst14_seg33 dst14_seg33 dst14_seg33_res 2.550000e-01
l_lev4_src7_dst14_seg33 dst14_seg33_res dst14_seg34 5.100000e-11
c_lev4_src7_dst14_seg33 dst14_seg34 0 4.900000e-15

r_lev4_src7_dst14_seg34 dst14_seg34 dst14_seg34_res 2.550000e-01
l_lev4_src7_dst14_seg34 dst14_seg34_res dst14_seg35 5.100000e-11
c_lev4_src7_dst14_seg34 dst14_seg35 0 4.900000e-15

r_lev4_src7_dst14_seg35 dst14_seg35 dst14_seg35_res 2.550000e-01
l_lev4_src7_dst14_seg35 dst14_seg35_res dst14_seg36 5.100000e-11
c_lev4_src7_dst14_seg35 dst14_seg36 0 4.900000e-15

r_lev4_src7_dst14_seg36 dst14_seg36 dst14_seg36_res 2.550000e-01
l_lev4_src7_dst14_seg36 dst14_seg36_res dst14_seg37 5.100000e-11
c_lev4_src7_dst14_seg36 dst14_seg37 0 4.900000e-15

r_lev4_src7_dst14_seg37 dst14_seg37 dst14_seg37_res 2.550000e-01
l_lev4_src7_dst14_seg37 dst14_seg37_res dst14_seg38 5.100000e-11
c_lev4_src7_dst14_seg37 dst14_seg38 0 4.900000e-15

r_lev4_src7_dst14_seg38 dst14_seg38 dst14_seg38_res 2.550000e-01
l_lev4_src7_dst14_seg38 dst14_seg38_res dst14_seg39 5.100000e-11
c_lev4_src7_dst14_seg38 dst14_seg39 0 4.900000e-15

r_lev4_src7_dst14_seg39 dst14_seg39 dst14_seg39_res 2.550000e-01
l_lev4_src7_dst14_seg39 dst14_seg39_res dst14_seg40 5.100000e-11
c_lev4_src7_dst14_seg39 dst14_seg40 0 4.900000e-15

r_lev4_src7_dst14_seg40 dst14_seg40 dst14_seg40_res 2.550000e-01
l_lev4_src7_dst14_seg40 dst14_seg40_res pt14 5.100000e-11
c_lev4_src7_dst14_seg40 pt14 0 4.900000e-15

r_lev4_dst14_load pt14 0 5.000000e+03
c_lev4_dst14_load pt14 0 5.000000e-15

r_lev4_src8_dst15_seg1 pt8 dst15_seg1_res 2.550000e-01
l_lev4_src8_dst15_seg1 dst15_seg1_res dst15_seg2 5.100000e-11
c_lev4_src8_dst15_seg1 dst15_seg2 0 4.900000e-15

r_lev4_src8_dst15_seg2 dst15_seg2 dst15_seg2_res 2.550000e-01
l_lev4_src8_dst15_seg2 dst15_seg2_res dst15_seg3 5.100000e-11
c_lev4_src8_dst15_seg2 dst15_seg3 0 4.900000e-15

r_lev4_src8_dst15_seg3 dst15_seg3 dst15_seg3_res 2.550000e-01
l_lev4_src8_dst15_seg3 dst15_seg3_res dst15_seg4 5.100000e-11
c_lev4_src8_dst15_seg3 dst15_seg4 0 4.900000e-15

r_lev4_src8_dst15_seg4 dst15_seg4 dst15_seg4_res 2.550000e-01
l_lev4_src8_dst15_seg4 dst15_seg4_res dst15_seg5 5.100000e-11
c_lev4_src8_dst15_seg4 dst15_seg5 0 4.900000e-15

r_lev4_src8_dst15_seg5 dst15_seg5 dst15_seg5_res 2.550000e-01
l_lev4_src8_dst15_seg5 dst15_seg5_res dst15_seg6 5.100000e-11
c_lev4_src8_dst15_seg5 dst15_seg6 0 4.900000e-15

r_lev4_src8_dst15_seg6 dst15_seg6 dst15_seg6_res 2.550000e-01
l_lev4_src8_dst15_seg6 dst15_seg6_res dst15_seg7 5.100000e-11
c_lev4_src8_dst15_seg6 dst15_seg7 0 4.900000e-15

r_lev4_src8_dst15_seg7 dst15_seg7 dst15_seg7_res 2.550000e-01
l_lev4_src8_dst15_seg7 dst15_seg7_res dst15_seg8 5.100000e-11
c_lev4_src8_dst15_seg7 dst15_seg8 0 4.900000e-15

r_lev4_src8_dst15_seg8 dst15_seg8 dst15_seg8_res 2.550000e-01
l_lev4_src8_dst15_seg8 dst15_seg8_res dst15_seg9 5.100000e-11
c_lev4_src8_dst15_seg8 dst15_seg9 0 4.900000e-15

r_lev4_src8_dst15_seg9 dst15_seg9 dst15_seg9_res 2.550000e-01
l_lev4_src8_dst15_seg9 dst15_seg9_res dst15_seg10 5.100000e-11
c_lev4_src8_dst15_seg9 dst15_seg10 0 4.900000e-15

r_lev4_src8_dst15_seg10 dst15_seg10 dst15_seg10_res 2.550000e-01
l_lev4_src8_dst15_seg10 dst15_seg10_res dst15_seg11 5.100000e-11
c_lev4_src8_dst15_seg10 dst15_seg11 0 4.900000e-15

r_lev4_src8_dst15_seg11 dst15_seg11 dst15_seg11_res 2.550000e-01
l_lev4_src8_dst15_seg11 dst15_seg11_res dst15_seg12 5.100000e-11
c_lev4_src8_dst15_seg11 dst15_seg12 0 4.900000e-15

r_lev4_src8_dst15_seg12 dst15_seg12 dst15_seg12_res 2.550000e-01
l_lev4_src8_dst15_seg12 dst15_seg12_res dst15_seg13 5.100000e-11
c_lev4_src8_dst15_seg12 dst15_seg13 0 4.900000e-15

r_lev4_src8_dst15_seg13 dst15_seg13 dst15_seg13_res 2.550000e-01
l_lev4_src8_dst15_seg13 dst15_seg13_res dst15_seg14 5.100000e-11
c_lev4_src8_dst15_seg13 dst15_seg14 0 4.900000e-15

r_lev4_src8_dst15_seg14 dst15_seg14 dst15_seg14_res 2.550000e-01
l_lev4_src8_dst15_seg14 dst15_seg14_res dst15_seg15 5.100000e-11
c_lev4_src8_dst15_seg14 dst15_seg15 0 4.900000e-15

r_lev4_src8_dst15_seg15 dst15_seg15 dst15_seg15_res 2.550000e-01
l_lev4_src8_dst15_seg15 dst15_seg15_res dst15_seg16 5.100000e-11
c_lev4_src8_dst15_seg15 dst15_seg16 0 4.900000e-15

r_lev4_src8_dst15_seg16 dst15_seg16 dst15_seg16_res 2.550000e-01
l_lev4_src8_dst15_seg16 dst15_seg16_res dst15_seg17 5.100000e-11
c_lev4_src8_dst15_seg16 dst15_seg17 0 4.900000e-15

r_lev4_src8_dst15_seg17 dst15_seg17 dst15_seg17_res 2.550000e-01
l_lev4_src8_dst15_seg17 dst15_seg17_res dst15_seg18 5.100000e-11
c_lev4_src8_dst15_seg17 dst15_seg18 0 4.900000e-15

r_lev4_src8_dst15_seg18 dst15_seg18 dst15_seg18_res 2.550000e-01
l_lev4_src8_dst15_seg18 dst15_seg18_res dst15_seg19 5.100000e-11
c_lev4_src8_dst15_seg18 dst15_seg19 0 4.900000e-15

r_lev4_src8_dst15_seg19 dst15_seg19 dst15_seg19_res 2.550000e-01
l_lev4_src8_dst15_seg19 dst15_seg19_res dst15_seg20 5.100000e-11
c_lev4_src8_dst15_seg19 dst15_seg20 0 4.900000e-15

r_lev4_src8_dst15_seg20 dst15_seg20 dst15_seg20_res 2.550000e-01
l_lev4_src8_dst15_seg20 dst15_seg20_res dst15_seg21 5.100000e-11
c_lev4_src8_dst15_seg20 dst15_seg21 0 4.900000e-15

r_lev4_src8_dst15_seg21 dst15_seg21 dst15_seg21_res 2.550000e-01
l_lev4_src8_dst15_seg21 dst15_seg21_res dst15_seg22 5.100000e-11
c_lev4_src8_dst15_seg21 dst15_seg22 0 4.900000e-15

r_lev4_src8_dst15_seg22 dst15_seg22 dst15_seg22_res 2.550000e-01
l_lev4_src8_dst15_seg22 dst15_seg22_res dst15_seg23 5.100000e-11
c_lev4_src8_dst15_seg22 dst15_seg23 0 4.900000e-15

r_lev4_src8_dst15_seg23 dst15_seg23 dst15_seg23_res 2.550000e-01
l_lev4_src8_dst15_seg23 dst15_seg23_res dst15_seg24 5.100000e-11
c_lev4_src8_dst15_seg23 dst15_seg24 0 4.900000e-15

r_lev4_src8_dst15_seg24 dst15_seg24 dst15_seg24_res 2.550000e-01
l_lev4_src8_dst15_seg24 dst15_seg24_res dst15_seg25 5.100000e-11
c_lev4_src8_dst15_seg24 dst15_seg25 0 4.900000e-15

r_lev4_src8_dst15_seg25 dst15_seg25 dst15_seg25_res 2.550000e-01
l_lev4_src8_dst15_seg25 dst15_seg25_res dst15_seg26 5.100000e-11
c_lev4_src8_dst15_seg25 dst15_seg26 0 4.900000e-15

r_lev4_src8_dst15_seg26 dst15_seg26 dst15_seg26_res 2.550000e-01
l_lev4_src8_dst15_seg26 dst15_seg26_res dst15_seg27 5.100000e-11
c_lev4_src8_dst15_seg26 dst15_seg27 0 4.900000e-15

r_lev4_src8_dst15_seg27 dst15_seg27 dst15_seg27_res 2.550000e-01
l_lev4_src8_dst15_seg27 dst15_seg27_res dst15_seg28 5.100000e-11
c_lev4_src8_dst15_seg27 dst15_seg28 0 4.900000e-15

r_lev4_src8_dst15_seg28 dst15_seg28 dst15_seg28_res 2.550000e-01
l_lev4_src8_dst15_seg28 dst15_seg28_res dst15_seg29 5.100000e-11
c_lev4_src8_dst15_seg28 dst15_seg29 0 4.900000e-15

r_lev4_src8_dst15_seg29 dst15_seg29 dst15_seg29_res 2.550000e-01
l_lev4_src8_dst15_seg29 dst15_seg29_res dst15_seg30 5.100000e-11
c_lev4_src8_dst15_seg29 dst15_seg30 0 4.900000e-15

r_lev4_src8_dst15_seg30 dst15_seg30 dst15_seg30_res 2.550000e-01
l_lev4_src8_dst15_seg30 dst15_seg30_res dst15_seg31 5.100000e-11
c_lev4_src8_dst15_seg30 dst15_seg31 0 4.900000e-15

r_lev4_src8_dst15_seg31 dst15_seg31 dst15_seg31_res 2.550000e-01
l_lev4_src8_dst15_seg31 dst15_seg31_res dst15_seg32 5.100000e-11
c_lev4_src8_dst15_seg31 dst15_seg32 0 4.900000e-15

r_lev4_src8_dst15_seg32 dst15_seg32 dst15_seg32_res 2.550000e-01
l_lev4_src8_dst15_seg32 dst15_seg32_res dst15_seg33 5.100000e-11
c_lev4_src8_dst15_seg32 dst15_seg33 0 4.900000e-15

r_lev4_src8_dst15_seg33 dst15_seg33 dst15_seg33_res 2.550000e-01
l_lev4_src8_dst15_seg33 dst15_seg33_res dst15_seg34 5.100000e-11
c_lev4_src8_dst15_seg33 dst15_seg34 0 4.900000e-15

r_lev4_src8_dst15_seg34 dst15_seg34 dst15_seg34_res 2.550000e-01
l_lev4_src8_dst15_seg34 dst15_seg34_res dst15_seg35 5.100000e-11
c_lev4_src8_dst15_seg34 dst15_seg35 0 4.900000e-15

r_lev4_src8_dst15_seg35 dst15_seg35 dst15_seg35_res 2.550000e-01
l_lev4_src8_dst15_seg35 dst15_seg35_res dst15_seg36 5.100000e-11
c_lev4_src8_dst15_seg35 dst15_seg36 0 4.900000e-15

r_lev4_src8_dst15_seg36 dst15_seg36 dst15_seg36_res 2.550000e-01
l_lev4_src8_dst15_seg36 dst15_seg36_res dst15_seg37 5.100000e-11
c_lev4_src8_dst15_seg36 dst15_seg37 0 4.900000e-15

r_lev4_src8_dst15_seg37 dst15_seg37 dst15_seg37_res 2.550000e-01
l_lev4_src8_dst15_seg37 dst15_seg37_res dst15_seg38 5.100000e-11
c_lev4_src8_dst15_seg37 dst15_seg38 0 4.900000e-15

r_lev4_src8_dst15_seg38 dst15_seg38 dst15_seg38_res 2.550000e-01
l_lev4_src8_dst15_seg38 dst15_seg38_res dst15_seg39 5.100000e-11
c_lev4_src8_dst15_seg38 dst15_seg39 0 4.900000e-15

r_lev4_src8_dst15_seg39 dst15_seg39 dst15_seg39_res 2.550000e-01
l_lev4_src8_dst15_seg39 dst15_seg39_res dst15_seg40 5.100000e-11
c_lev4_src8_dst15_seg39 dst15_seg40 0 4.900000e-15

r_lev4_src8_dst15_seg40 dst15_seg40 dst15_seg40_res 2.550000e-01
l_lev4_src8_dst15_seg40 dst15_seg40_res pt15 5.100000e-11
c_lev4_src8_dst15_seg40 pt15 0 4.900000e-15

r_lev4_dst15_load pt15 0 5.000000e+03
c_lev4_dst15_load pt15 0 5.000000e-15

r_lev4_src8_dst16_seg1 pt8 dst16_seg1_res 2.550000e-01
l_lev4_src8_dst16_seg1 dst16_seg1_res dst16_seg2 5.100000e-11
c_lev4_src8_dst16_seg1 dst16_seg2 0 4.900000e-15

r_lev4_src8_dst16_seg2 dst16_seg2 dst16_seg2_res 2.550000e-01
l_lev4_src8_dst16_seg2 dst16_seg2_res dst16_seg3 5.100000e-11
c_lev4_src8_dst16_seg2 dst16_seg3 0 4.900000e-15

r_lev4_src8_dst16_seg3 dst16_seg3 dst16_seg3_res 2.550000e-01
l_lev4_src8_dst16_seg3 dst16_seg3_res dst16_seg4 5.100000e-11
c_lev4_src8_dst16_seg3 dst16_seg4 0 4.900000e-15

r_lev4_src8_dst16_seg4 dst16_seg4 dst16_seg4_res 2.550000e-01
l_lev4_src8_dst16_seg4 dst16_seg4_res dst16_seg5 5.100000e-11
c_lev4_src8_dst16_seg4 dst16_seg5 0 4.900000e-15

r_lev4_src8_dst16_seg5 dst16_seg5 dst16_seg5_res 2.550000e-01
l_lev4_src8_dst16_seg5 dst16_seg5_res dst16_seg6 5.100000e-11
c_lev4_src8_dst16_seg5 dst16_seg6 0 4.900000e-15

r_lev4_src8_dst16_seg6 dst16_seg6 dst16_seg6_res 2.550000e-01
l_lev4_src8_dst16_seg6 dst16_seg6_res dst16_seg7 5.100000e-11
c_lev4_src8_dst16_seg6 dst16_seg7 0 4.900000e-15

r_lev4_src8_dst16_seg7 dst16_seg7 dst16_seg7_res 2.550000e-01
l_lev4_src8_dst16_seg7 dst16_seg7_res dst16_seg8 5.100000e-11
c_lev4_src8_dst16_seg7 dst16_seg8 0 4.900000e-15

r_lev4_src8_dst16_seg8 dst16_seg8 dst16_seg8_res 2.550000e-01
l_lev4_src8_dst16_seg8 dst16_seg8_res dst16_seg9 5.100000e-11
c_lev4_src8_dst16_seg8 dst16_seg9 0 4.900000e-15

r_lev4_src8_dst16_seg9 dst16_seg9 dst16_seg9_res 2.550000e-01
l_lev4_src8_dst16_seg9 dst16_seg9_res dst16_seg10 5.100000e-11
c_lev4_src8_dst16_seg9 dst16_seg10 0 4.900000e-15

r_lev4_src8_dst16_seg10 dst16_seg10 dst16_seg10_res 2.550000e-01
l_lev4_src8_dst16_seg10 dst16_seg10_res dst16_seg11 5.100000e-11
c_lev4_src8_dst16_seg10 dst16_seg11 0 4.900000e-15

r_lev4_src8_dst16_seg11 dst16_seg11 dst16_seg11_res 2.550000e-01
l_lev4_src8_dst16_seg11 dst16_seg11_res dst16_seg12 5.100000e-11
c_lev4_src8_dst16_seg11 dst16_seg12 0 4.900000e-15

r_lev4_src8_dst16_seg12 dst16_seg12 dst16_seg12_res 2.550000e-01
l_lev4_src8_dst16_seg12 dst16_seg12_res dst16_seg13 5.100000e-11
c_lev4_src8_dst16_seg12 dst16_seg13 0 4.900000e-15

r_lev4_src8_dst16_seg13 dst16_seg13 dst16_seg13_res 2.550000e-01
l_lev4_src8_dst16_seg13 dst16_seg13_res dst16_seg14 5.100000e-11
c_lev4_src8_dst16_seg13 dst16_seg14 0 4.900000e-15

r_lev4_src8_dst16_seg14 dst16_seg14 dst16_seg14_res 2.550000e-01
l_lev4_src8_dst16_seg14 dst16_seg14_res dst16_seg15 5.100000e-11
c_lev4_src8_dst16_seg14 dst16_seg15 0 4.900000e-15

r_lev4_src8_dst16_seg15 dst16_seg15 dst16_seg15_res 2.550000e-01
l_lev4_src8_dst16_seg15 dst16_seg15_res dst16_seg16 5.100000e-11
c_lev4_src8_dst16_seg15 dst16_seg16 0 4.900000e-15

r_lev4_src8_dst16_seg16 dst16_seg16 dst16_seg16_res 2.550000e-01
l_lev4_src8_dst16_seg16 dst16_seg16_res dst16_seg17 5.100000e-11
c_lev4_src8_dst16_seg16 dst16_seg17 0 4.900000e-15

r_lev4_src8_dst16_seg17 dst16_seg17 dst16_seg17_res 2.550000e-01
l_lev4_src8_dst16_seg17 dst16_seg17_res dst16_seg18 5.100000e-11
c_lev4_src8_dst16_seg17 dst16_seg18 0 4.900000e-15

r_lev4_src8_dst16_seg18 dst16_seg18 dst16_seg18_res 2.550000e-01
l_lev4_src8_dst16_seg18 dst16_seg18_res dst16_seg19 5.100000e-11
c_lev4_src8_dst16_seg18 dst16_seg19 0 4.900000e-15

r_lev4_src8_dst16_seg19 dst16_seg19 dst16_seg19_res 2.550000e-01
l_lev4_src8_dst16_seg19 dst16_seg19_res dst16_seg20 5.100000e-11
c_lev4_src8_dst16_seg19 dst16_seg20 0 4.900000e-15

r_lev4_src8_dst16_seg20 dst16_seg20 dst16_seg20_res 2.550000e-01
l_lev4_src8_dst16_seg20 dst16_seg20_res dst16_seg21 5.100000e-11
c_lev4_src8_dst16_seg20 dst16_seg21 0 4.900000e-15

r_lev4_src8_dst16_seg21 dst16_seg21 dst16_seg21_res 2.550000e-01
l_lev4_src8_dst16_seg21 dst16_seg21_res dst16_seg22 5.100000e-11
c_lev4_src8_dst16_seg21 dst16_seg22 0 4.900000e-15

r_lev4_src8_dst16_seg22 dst16_seg22 dst16_seg22_res 2.550000e-01
l_lev4_src8_dst16_seg22 dst16_seg22_res dst16_seg23 5.100000e-11
c_lev4_src8_dst16_seg22 dst16_seg23 0 4.900000e-15

r_lev4_src8_dst16_seg23 dst16_seg23 dst16_seg23_res 2.550000e-01
l_lev4_src8_dst16_seg23 dst16_seg23_res dst16_seg24 5.100000e-11
c_lev4_src8_dst16_seg23 dst16_seg24 0 4.900000e-15

r_lev4_src8_dst16_seg24 dst16_seg24 dst16_seg24_res 2.550000e-01
l_lev4_src8_dst16_seg24 dst16_seg24_res dst16_seg25 5.100000e-11
c_lev4_src8_dst16_seg24 dst16_seg25 0 4.900000e-15

r_lev4_src8_dst16_seg25 dst16_seg25 dst16_seg25_res 2.550000e-01
l_lev4_src8_dst16_seg25 dst16_seg25_res dst16_seg26 5.100000e-11
c_lev4_src8_dst16_seg25 dst16_seg26 0 4.900000e-15

r_lev4_src8_dst16_seg26 dst16_seg26 dst16_seg26_res 2.550000e-01
l_lev4_src8_dst16_seg26 dst16_seg26_res dst16_seg27 5.100000e-11
c_lev4_src8_dst16_seg26 dst16_seg27 0 4.900000e-15

r_lev4_src8_dst16_seg27 dst16_seg27 dst16_seg27_res 2.550000e-01
l_lev4_src8_dst16_seg27 dst16_seg27_res dst16_seg28 5.100000e-11
c_lev4_src8_dst16_seg27 dst16_seg28 0 4.900000e-15

r_lev4_src8_dst16_seg28 dst16_seg28 dst16_seg28_res 2.550000e-01
l_lev4_src8_dst16_seg28 dst16_seg28_res dst16_seg29 5.100000e-11
c_lev4_src8_dst16_seg28 dst16_seg29 0 4.900000e-15

r_lev4_src8_dst16_seg29 dst16_seg29 dst16_seg29_res 2.550000e-01
l_lev4_src8_dst16_seg29 dst16_seg29_res dst16_seg30 5.100000e-11
c_lev4_src8_dst16_seg29 dst16_seg30 0 4.900000e-15

r_lev4_src8_dst16_seg30 dst16_seg30 dst16_seg30_res 2.550000e-01
l_lev4_src8_dst16_seg30 dst16_seg30_res dst16_seg31 5.100000e-11
c_lev4_src8_dst16_seg30 dst16_seg31 0 4.900000e-15

r_lev4_src8_dst16_seg31 dst16_seg31 dst16_seg31_res 2.550000e-01
l_lev4_src8_dst16_seg31 dst16_seg31_res dst16_seg32 5.100000e-11
c_lev4_src8_dst16_seg31 dst16_seg32 0 4.900000e-15

r_lev4_src8_dst16_seg32 dst16_seg32 dst16_seg32_res 2.550000e-01
l_lev4_src8_dst16_seg32 dst16_seg32_res dst16_seg33 5.100000e-11
c_lev4_src8_dst16_seg32 dst16_seg33 0 4.900000e-15

r_lev4_src8_dst16_seg33 dst16_seg33 dst16_seg33_res 2.550000e-01
l_lev4_src8_dst16_seg33 dst16_seg33_res dst16_seg34 5.100000e-11
c_lev4_src8_dst16_seg33 dst16_seg34 0 4.900000e-15

r_lev4_src8_dst16_seg34 dst16_seg34 dst16_seg34_res 2.550000e-01
l_lev4_src8_dst16_seg34 dst16_seg34_res dst16_seg35 5.100000e-11
c_lev4_src8_dst16_seg34 dst16_seg35 0 4.900000e-15

r_lev4_src8_dst16_seg35 dst16_seg35 dst16_seg35_res 2.550000e-01
l_lev4_src8_dst16_seg35 dst16_seg35_res dst16_seg36 5.100000e-11
c_lev4_src8_dst16_seg35 dst16_seg36 0 4.900000e-15

r_lev4_src8_dst16_seg36 dst16_seg36 dst16_seg36_res 2.550000e-01
l_lev4_src8_dst16_seg36 dst16_seg36_res dst16_seg37 5.100000e-11
c_lev4_src8_dst16_seg36 dst16_seg37 0 4.900000e-15

r_lev4_src8_dst16_seg37 dst16_seg37 dst16_seg37_res 2.550000e-01
l_lev4_src8_dst16_seg37 dst16_seg37_res dst16_seg38 5.100000e-11
c_lev4_src8_dst16_seg37 dst16_seg38 0 4.900000e-15

r_lev4_src8_dst16_seg38 dst16_seg38 dst16_seg38_res 2.550000e-01
l_lev4_src8_dst16_seg38 dst16_seg38_res dst16_seg39 5.100000e-11
c_lev4_src8_dst16_seg38 dst16_seg39 0 4.900000e-15

r_lev4_src8_dst16_seg39 dst16_seg39 dst16_seg39_res 2.550000e-01
l_lev4_src8_dst16_seg39 dst16_seg39_res dst16_seg40 5.100000e-11
c_lev4_src8_dst16_seg39 dst16_seg40 0 4.900000e-15

r_lev4_src8_dst16_seg40 dst16_seg40 dst16_seg40_res 2.550000e-01
l_lev4_src8_dst16_seg40 dst16_seg40_res pt16 5.100000e-11
c_lev4_src8_dst16_seg40 pt16 0 4.900000e-15

r_lev4_dst16_load pt16 0 5.000000e+03
c_lev4_dst16_load pt16 0 5.000000e-15
